VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO sram_8x8_9T
  CLASS BLOCK ;
  FOREIGN sram_8x8_9T ;
  ORIGIN 0.855 0.540 ;
  SIZE 26.625 BY 44.880 ;
  OBS
      LAYER Nwell ;
        RECT -0.855 2.250 25.770 42.635 ;
      LAYER Metal1 ;
        RECT -0.685 0.000 25.555 43.840 ;
      LAYER Metal2 ;
        RECT -0.755 0.030 25.625 43.355 ;
      LAYER Metal3 ;
        RECT 0.520 0.000 24.855 43.840 ;
      LAYER Metal4 ;
        RECT 0.605 -0.540 24.770 44.340 ;
  END
END sram_8x8_9T
END LIBRARY

