VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO sram_8x8_9T
  CLASS BLOCK ;
  FOREIGN sram_8x8_9T ;
  ORIGIN 0.855 0.540 ;
  SIZE 26.625 BY 44.880 ;
  OBS
      LAYER Nwell ;
        RECT -0.855 40.610 25.770 42.635 ;
        RECT -0.855 35.130 25.770 37.155 ;
        RECT -0.855 29.650 25.770 31.675 ;
        RECT -0.855 24.170 25.770 26.195 ;
        RECT -0.855 18.690 25.770 20.715 ;
        RECT -0.855 13.210 25.770 15.235 ;
        RECT -0.855 7.730 25.770 9.755 ;
        RECT -0.855 2.250 25.770 4.275 ;
      LAYER Metal1 ;
        RECT 1.435 43.605 2.005 43.840 ;
        RECT 4.545 43.605 5.115 43.840 ;
        RECT 7.655 43.605 8.225 43.840 ;
        RECT 10.765 43.605 11.335 43.840 ;
        RECT 13.875 43.605 14.445 43.840 ;
        RECT 16.985 43.605 17.555 43.840 ;
        RECT 20.095 43.605 20.665 43.840 ;
        RECT 23.205 43.605 23.775 43.840 ;
        RECT 1.710 43.425 2.005 43.605 ;
        RECT 4.820 43.425 5.115 43.605 ;
        RECT 7.930 43.425 8.225 43.605 ;
        RECT 11.040 43.425 11.335 43.605 ;
        RECT 14.150 43.425 14.445 43.605 ;
        RECT 17.260 43.425 17.555 43.605 ;
        RECT 20.370 43.425 20.665 43.605 ;
        RECT 23.480 43.425 23.775 43.605 ;
        RECT 0.185 42.205 0.545 43.375 ;
        RECT 1.025 42.780 1.390 43.375 ;
        RECT 1.710 43.065 2.070 43.425 ;
        RECT 2.550 43.125 2.910 43.360 ;
        RECT 2.575 42.780 2.910 43.125 ;
        RECT 1.025 42.535 2.910 42.780 ;
        RECT 1.025 42.455 2.670 42.535 ;
        RECT 0.185 41.760 1.790 42.205 ;
        RECT 2.300 41.765 2.670 42.455 ;
        RECT 3.295 42.205 3.655 43.375 ;
        RECT 4.135 42.780 4.500 43.375 ;
        RECT 4.820 43.065 5.180 43.425 ;
        RECT 5.660 43.125 6.020 43.360 ;
        RECT 5.685 42.780 6.020 43.125 ;
        RECT 4.135 42.535 6.020 42.780 ;
        RECT 4.135 42.455 5.780 42.535 ;
        RECT 3.295 41.760 4.900 42.205 ;
        RECT 5.410 41.765 5.780 42.455 ;
        RECT 6.405 42.205 6.765 43.375 ;
        RECT 7.245 42.780 7.610 43.375 ;
        RECT 7.930 43.065 8.290 43.425 ;
        RECT 8.770 43.125 9.130 43.360 ;
        RECT 8.795 42.780 9.130 43.125 ;
        RECT 7.245 42.535 9.130 42.780 ;
        RECT 7.245 42.455 8.890 42.535 ;
        RECT 6.405 41.760 8.010 42.205 ;
        RECT 8.520 41.765 8.890 42.455 ;
        RECT 9.515 42.205 9.875 43.375 ;
        RECT 10.355 42.780 10.720 43.375 ;
        RECT 11.040 43.065 11.400 43.425 ;
        RECT 11.880 43.125 12.240 43.360 ;
        RECT 11.905 42.780 12.240 43.125 ;
        RECT 10.355 42.535 12.240 42.780 ;
        RECT 10.355 42.455 12.000 42.535 ;
        RECT 9.515 41.760 11.120 42.205 ;
        RECT 11.630 41.765 12.000 42.455 ;
        RECT 12.625 42.205 12.985 43.375 ;
        RECT 13.465 42.780 13.830 43.375 ;
        RECT 14.150 43.065 14.510 43.425 ;
        RECT 14.990 43.125 15.350 43.360 ;
        RECT 15.015 42.780 15.350 43.125 ;
        RECT 13.465 42.535 15.350 42.780 ;
        RECT 13.465 42.455 15.110 42.535 ;
        RECT 12.625 41.760 14.230 42.205 ;
        RECT 14.740 41.765 15.110 42.455 ;
        RECT 15.735 42.205 16.095 43.375 ;
        RECT 16.575 42.780 16.940 43.375 ;
        RECT 17.260 43.065 17.620 43.425 ;
        RECT 18.100 43.125 18.460 43.360 ;
        RECT 18.125 42.780 18.460 43.125 ;
        RECT 16.575 42.535 18.460 42.780 ;
        RECT 16.575 42.455 18.220 42.535 ;
        RECT 15.735 41.760 17.340 42.205 ;
        RECT 17.850 41.765 18.220 42.455 ;
        RECT 18.845 42.205 19.205 43.375 ;
        RECT 19.685 42.780 20.050 43.375 ;
        RECT 20.370 43.065 20.730 43.425 ;
        RECT 21.210 43.125 21.570 43.360 ;
        RECT 21.235 42.780 21.570 43.125 ;
        RECT 19.685 42.535 21.570 42.780 ;
        RECT 19.685 42.455 21.330 42.535 ;
        RECT 18.845 41.760 20.450 42.205 ;
        RECT 20.960 41.765 21.330 42.455 ;
        RECT 21.955 42.205 22.315 43.375 ;
        RECT 22.795 42.780 23.160 43.375 ;
        RECT 23.480 43.065 23.840 43.425 ;
        RECT 24.320 43.125 24.680 43.360 ;
        RECT 24.345 42.780 24.680 43.125 ;
        RECT 22.795 42.535 24.680 42.780 ;
        RECT 22.795 42.455 24.440 42.535 ;
        RECT 21.955 41.760 23.560 42.205 ;
        RECT 24.070 41.765 24.440 42.455 ;
        RECT -0.685 40.785 0.130 41.350 ;
        RECT 0.360 41.150 0.845 41.480 ;
        RECT 1.250 41.170 1.785 41.490 ;
        RECT 2.275 41.150 2.780 41.485 ;
        RECT 0.360 40.345 0.805 41.150 ;
        RECT 1.095 40.870 1.325 40.915 ;
        RECT 2.335 40.870 2.780 41.150 ;
        RECT 1.095 40.640 2.780 40.870 ;
        RECT 1.095 40.575 1.325 40.640 ;
        RECT 1.830 40.345 2.060 40.410 ;
        RECT -0.685 39.650 0.000 40.215 ;
        RECT 0.360 40.115 2.060 40.345 ;
        RECT 0.360 39.670 0.825 40.115 ;
        RECT 1.830 40.070 2.060 40.115 ;
        RECT 2.335 40.020 2.780 40.640 ;
        RECT 1.335 39.575 1.790 39.840 ;
        RECT 2.290 39.655 2.780 40.020 ;
        RECT 3.470 41.150 3.955 41.480 ;
        RECT 4.360 41.170 4.895 41.490 ;
        RECT 5.385 41.150 5.890 41.485 ;
        RECT 3.470 40.345 3.915 41.150 ;
        RECT 4.205 40.870 4.435 40.915 ;
        RECT 5.445 40.870 5.890 41.150 ;
        RECT 4.205 40.640 5.890 40.870 ;
        RECT 4.205 40.575 4.435 40.640 ;
        RECT 4.940 40.345 5.170 40.410 ;
        RECT 3.470 40.115 5.170 40.345 ;
        RECT 3.470 39.670 3.935 40.115 ;
        RECT 4.940 40.070 5.170 40.115 ;
        RECT 5.445 40.020 5.890 40.640 ;
        RECT 4.445 39.575 4.900 39.840 ;
        RECT 5.400 39.655 5.890 40.020 ;
        RECT 6.580 41.150 7.065 41.480 ;
        RECT 7.470 41.170 8.005 41.490 ;
        RECT 8.495 41.150 9.000 41.485 ;
        RECT 6.580 40.345 7.025 41.150 ;
        RECT 7.315 40.870 7.545 40.915 ;
        RECT 8.555 40.870 9.000 41.150 ;
        RECT 7.315 40.640 9.000 40.870 ;
        RECT 7.315 40.575 7.545 40.640 ;
        RECT 8.050 40.345 8.280 40.410 ;
        RECT 6.580 40.115 8.280 40.345 ;
        RECT 6.580 39.670 7.045 40.115 ;
        RECT 8.050 40.070 8.280 40.115 ;
        RECT 8.555 40.020 9.000 40.640 ;
        RECT 7.555 39.575 8.010 39.840 ;
        RECT 8.510 39.655 9.000 40.020 ;
        RECT 9.690 41.150 10.175 41.480 ;
        RECT 10.580 41.170 11.115 41.490 ;
        RECT 11.605 41.150 12.110 41.485 ;
        RECT 9.690 40.345 10.135 41.150 ;
        RECT 10.425 40.870 10.655 40.915 ;
        RECT 11.665 40.870 12.110 41.150 ;
        RECT 10.425 40.640 12.110 40.870 ;
        RECT 10.425 40.575 10.655 40.640 ;
        RECT 11.160 40.345 11.390 40.410 ;
        RECT 9.690 40.115 11.390 40.345 ;
        RECT 9.690 39.670 10.155 40.115 ;
        RECT 11.160 40.070 11.390 40.115 ;
        RECT 11.665 40.020 12.110 40.640 ;
        RECT 10.665 39.575 11.120 39.840 ;
        RECT 11.620 39.655 12.110 40.020 ;
        RECT 12.800 41.150 13.285 41.480 ;
        RECT 13.690 41.170 14.225 41.490 ;
        RECT 14.715 41.150 15.220 41.485 ;
        RECT 12.800 40.345 13.245 41.150 ;
        RECT 13.535 40.870 13.765 40.915 ;
        RECT 14.775 40.870 15.220 41.150 ;
        RECT 13.535 40.640 15.220 40.870 ;
        RECT 13.535 40.575 13.765 40.640 ;
        RECT 14.270 40.345 14.500 40.410 ;
        RECT 12.800 40.115 14.500 40.345 ;
        RECT 12.800 39.670 13.265 40.115 ;
        RECT 14.270 40.070 14.500 40.115 ;
        RECT 14.775 40.020 15.220 40.640 ;
        RECT 13.775 39.575 14.230 39.840 ;
        RECT 14.730 39.655 15.220 40.020 ;
        RECT 15.910 41.150 16.395 41.480 ;
        RECT 16.800 41.170 17.335 41.490 ;
        RECT 17.825 41.150 18.330 41.485 ;
        RECT 15.910 40.345 16.355 41.150 ;
        RECT 16.645 40.870 16.875 40.915 ;
        RECT 17.885 40.870 18.330 41.150 ;
        RECT 16.645 40.640 18.330 40.870 ;
        RECT 16.645 40.575 16.875 40.640 ;
        RECT 17.380 40.345 17.610 40.410 ;
        RECT 15.910 40.115 17.610 40.345 ;
        RECT 15.910 39.670 16.375 40.115 ;
        RECT 17.380 40.070 17.610 40.115 ;
        RECT 17.885 40.020 18.330 40.640 ;
        RECT 16.885 39.575 17.340 39.840 ;
        RECT 17.840 39.655 18.330 40.020 ;
        RECT 19.020 41.150 19.505 41.480 ;
        RECT 19.910 41.170 20.445 41.490 ;
        RECT 20.935 41.150 21.440 41.485 ;
        RECT 19.020 40.345 19.465 41.150 ;
        RECT 19.755 40.870 19.985 40.915 ;
        RECT 20.995 40.870 21.440 41.150 ;
        RECT 19.755 40.640 21.440 40.870 ;
        RECT 19.755 40.575 19.985 40.640 ;
        RECT 20.490 40.345 20.720 40.410 ;
        RECT 19.020 40.115 20.720 40.345 ;
        RECT 19.020 39.670 19.485 40.115 ;
        RECT 20.490 40.070 20.720 40.115 ;
        RECT 20.995 40.020 21.440 40.640 ;
        RECT 19.995 39.575 20.450 39.840 ;
        RECT 20.950 39.655 21.440 40.020 ;
        RECT 22.130 41.150 22.615 41.480 ;
        RECT 23.020 41.170 23.555 41.490 ;
        RECT 24.045 41.150 24.550 41.485 ;
        RECT 22.130 40.345 22.575 41.150 ;
        RECT 22.865 40.870 23.095 40.915 ;
        RECT 24.105 40.870 24.550 41.150 ;
        RECT 24.950 40.870 25.555 41.435 ;
        RECT 22.865 40.640 24.550 40.870 ;
        RECT 22.865 40.575 23.095 40.640 ;
        RECT 23.600 40.345 23.830 40.410 ;
        RECT 22.130 40.115 23.830 40.345 ;
        RECT 22.130 39.670 22.595 40.115 ;
        RECT 23.600 40.070 23.830 40.115 ;
        RECT 24.105 40.020 24.550 40.640 ;
        RECT 23.105 39.575 23.560 39.840 ;
        RECT 24.060 39.655 24.550 40.020 ;
        RECT 24.920 39.650 25.525 40.215 ;
        RECT 0.000 38.865 0.390 39.300 ;
        RECT 0.610 38.405 1.000 38.785 ;
        RECT 1.435 38.360 1.700 39.575 ;
        RECT 3.110 38.865 3.500 39.300 ;
        RECT 2.240 38.405 2.630 38.785 ;
        RECT 3.720 38.405 4.110 38.785 ;
        RECT 4.545 38.360 4.810 39.575 ;
        RECT 6.220 38.865 6.610 39.300 ;
        RECT 5.350 38.405 5.740 38.785 ;
        RECT 6.830 38.405 7.220 38.785 ;
        RECT 7.655 38.360 7.920 39.575 ;
        RECT 9.330 38.865 9.720 39.300 ;
        RECT 8.460 38.405 8.850 38.785 ;
        RECT 9.940 38.405 10.330 38.785 ;
        RECT 10.765 38.360 11.030 39.575 ;
        RECT 12.440 38.865 12.830 39.300 ;
        RECT 11.570 38.405 11.960 38.785 ;
        RECT 13.050 38.405 13.440 38.785 ;
        RECT 13.875 38.360 14.140 39.575 ;
        RECT 15.550 38.865 15.940 39.300 ;
        RECT 14.680 38.405 15.070 38.785 ;
        RECT 16.160 38.405 16.550 38.785 ;
        RECT 16.985 38.360 17.250 39.575 ;
        RECT 18.660 38.865 19.050 39.300 ;
        RECT 17.790 38.405 18.180 38.785 ;
        RECT 19.270 38.405 19.660 38.785 ;
        RECT 20.095 38.360 20.360 39.575 ;
        RECT 21.770 38.865 22.160 39.300 ;
        RECT 20.900 38.405 21.290 38.785 ;
        RECT 22.380 38.405 22.770 38.785 ;
        RECT 23.205 38.360 23.470 39.575 ;
        RECT 24.010 38.405 24.400 38.785 ;
        RECT 1.435 38.125 2.005 38.360 ;
        RECT 4.545 38.125 5.115 38.360 ;
        RECT 7.655 38.125 8.225 38.360 ;
        RECT 10.765 38.125 11.335 38.360 ;
        RECT 13.875 38.125 14.445 38.360 ;
        RECT 16.985 38.125 17.555 38.360 ;
        RECT 20.095 38.125 20.665 38.360 ;
        RECT 23.205 38.125 23.775 38.360 ;
        RECT 1.710 37.945 2.005 38.125 ;
        RECT 4.820 37.945 5.115 38.125 ;
        RECT 7.930 37.945 8.225 38.125 ;
        RECT 11.040 37.945 11.335 38.125 ;
        RECT 14.150 37.945 14.445 38.125 ;
        RECT 17.260 37.945 17.555 38.125 ;
        RECT 20.370 37.945 20.665 38.125 ;
        RECT 23.480 37.945 23.775 38.125 ;
        RECT 0.185 36.725 0.545 37.895 ;
        RECT 1.025 37.300 1.390 37.895 ;
        RECT 1.710 37.585 2.070 37.945 ;
        RECT 2.550 37.645 2.910 37.880 ;
        RECT 2.575 37.300 2.910 37.645 ;
        RECT 1.025 37.055 2.910 37.300 ;
        RECT 1.025 36.975 2.670 37.055 ;
        RECT 0.185 36.280 1.790 36.725 ;
        RECT 2.300 36.285 2.670 36.975 ;
        RECT 3.295 36.725 3.655 37.895 ;
        RECT 4.135 37.300 4.500 37.895 ;
        RECT 4.820 37.585 5.180 37.945 ;
        RECT 5.660 37.645 6.020 37.880 ;
        RECT 5.685 37.300 6.020 37.645 ;
        RECT 4.135 37.055 6.020 37.300 ;
        RECT 4.135 36.975 5.780 37.055 ;
        RECT 3.295 36.280 4.900 36.725 ;
        RECT 5.410 36.285 5.780 36.975 ;
        RECT 6.405 36.725 6.765 37.895 ;
        RECT 7.245 37.300 7.610 37.895 ;
        RECT 7.930 37.585 8.290 37.945 ;
        RECT 8.770 37.645 9.130 37.880 ;
        RECT 8.795 37.300 9.130 37.645 ;
        RECT 7.245 37.055 9.130 37.300 ;
        RECT 7.245 36.975 8.890 37.055 ;
        RECT 6.405 36.280 8.010 36.725 ;
        RECT 8.520 36.285 8.890 36.975 ;
        RECT 9.515 36.725 9.875 37.895 ;
        RECT 10.355 37.300 10.720 37.895 ;
        RECT 11.040 37.585 11.400 37.945 ;
        RECT 11.880 37.645 12.240 37.880 ;
        RECT 11.905 37.300 12.240 37.645 ;
        RECT 10.355 37.055 12.240 37.300 ;
        RECT 10.355 36.975 12.000 37.055 ;
        RECT 9.515 36.280 11.120 36.725 ;
        RECT 11.630 36.285 12.000 36.975 ;
        RECT 12.625 36.725 12.985 37.895 ;
        RECT 13.465 37.300 13.830 37.895 ;
        RECT 14.150 37.585 14.510 37.945 ;
        RECT 14.990 37.645 15.350 37.880 ;
        RECT 15.015 37.300 15.350 37.645 ;
        RECT 13.465 37.055 15.350 37.300 ;
        RECT 13.465 36.975 15.110 37.055 ;
        RECT 12.625 36.280 14.230 36.725 ;
        RECT 14.740 36.285 15.110 36.975 ;
        RECT 15.735 36.725 16.095 37.895 ;
        RECT 16.575 37.300 16.940 37.895 ;
        RECT 17.260 37.585 17.620 37.945 ;
        RECT 18.100 37.645 18.460 37.880 ;
        RECT 18.125 37.300 18.460 37.645 ;
        RECT 16.575 37.055 18.460 37.300 ;
        RECT 16.575 36.975 18.220 37.055 ;
        RECT 15.735 36.280 17.340 36.725 ;
        RECT 17.850 36.285 18.220 36.975 ;
        RECT 18.845 36.725 19.205 37.895 ;
        RECT 19.685 37.300 20.050 37.895 ;
        RECT 20.370 37.585 20.730 37.945 ;
        RECT 21.210 37.645 21.570 37.880 ;
        RECT 21.235 37.300 21.570 37.645 ;
        RECT 19.685 37.055 21.570 37.300 ;
        RECT 19.685 36.975 21.330 37.055 ;
        RECT 18.845 36.280 20.450 36.725 ;
        RECT 20.960 36.285 21.330 36.975 ;
        RECT 21.955 36.725 22.315 37.895 ;
        RECT 22.795 37.300 23.160 37.895 ;
        RECT 23.480 37.585 23.840 37.945 ;
        RECT 24.320 37.645 24.680 37.880 ;
        RECT 24.345 37.300 24.680 37.645 ;
        RECT 22.795 37.055 24.680 37.300 ;
        RECT 22.795 36.975 24.440 37.055 ;
        RECT 21.955 36.280 23.560 36.725 ;
        RECT 24.070 36.285 24.440 36.975 ;
        RECT -0.685 35.305 0.130 35.870 ;
        RECT 0.360 35.670 0.845 36.000 ;
        RECT 1.250 35.690 1.785 36.010 ;
        RECT 2.275 35.670 2.780 36.005 ;
        RECT 0.360 34.865 0.805 35.670 ;
        RECT 1.095 35.390 1.325 35.435 ;
        RECT 2.335 35.390 2.780 35.670 ;
        RECT 1.095 35.160 2.780 35.390 ;
        RECT 1.095 35.095 1.325 35.160 ;
        RECT 1.830 34.865 2.060 34.930 ;
        RECT -0.685 34.170 0.000 34.735 ;
        RECT 0.360 34.635 2.060 34.865 ;
        RECT 0.360 34.190 0.825 34.635 ;
        RECT 1.830 34.590 2.060 34.635 ;
        RECT 2.335 34.540 2.780 35.160 ;
        RECT 1.335 34.095 1.790 34.360 ;
        RECT 2.290 34.175 2.780 34.540 ;
        RECT 3.470 35.670 3.955 36.000 ;
        RECT 4.360 35.690 4.895 36.010 ;
        RECT 5.385 35.670 5.890 36.005 ;
        RECT 3.470 34.865 3.915 35.670 ;
        RECT 4.205 35.390 4.435 35.435 ;
        RECT 5.445 35.390 5.890 35.670 ;
        RECT 4.205 35.160 5.890 35.390 ;
        RECT 4.205 35.095 4.435 35.160 ;
        RECT 4.940 34.865 5.170 34.930 ;
        RECT 3.470 34.635 5.170 34.865 ;
        RECT 3.470 34.190 3.935 34.635 ;
        RECT 4.940 34.590 5.170 34.635 ;
        RECT 5.445 34.540 5.890 35.160 ;
        RECT 4.445 34.095 4.900 34.360 ;
        RECT 5.400 34.175 5.890 34.540 ;
        RECT 6.580 35.670 7.065 36.000 ;
        RECT 7.470 35.690 8.005 36.010 ;
        RECT 8.495 35.670 9.000 36.005 ;
        RECT 6.580 34.865 7.025 35.670 ;
        RECT 7.315 35.390 7.545 35.435 ;
        RECT 8.555 35.390 9.000 35.670 ;
        RECT 7.315 35.160 9.000 35.390 ;
        RECT 7.315 35.095 7.545 35.160 ;
        RECT 8.050 34.865 8.280 34.930 ;
        RECT 6.580 34.635 8.280 34.865 ;
        RECT 6.580 34.190 7.045 34.635 ;
        RECT 8.050 34.590 8.280 34.635 ;
        RECT 8.555 34.540 9.000 35.160 ;
        RECT 7.555 34.095 8.010 34.360 ;
        RECT 8.510 34.175 9.000 34.540 ;
        RECT 9.690 35.670 10.175 36.000 ;
        RECT 10.580 35.690 11.115 36.010 ;
        RECT 11.605 35.670 12.110 36.005 ;
        RECT 9.690 34.865 10.135 35.670 ;
        RECT 10.425 35.390 10.655 35.435 ;
        RECT 11.665 35.390 12.110 35.670 ;
        RECT 10.425 35.160 12.110 35.390 ;
        RECT 10.425 35.095 10.655 35.160 ;
        RECT 11.160 34.865 11.390 34.930 ;
        RECT 9.690 34.635 11.390 34.865 ;
        RECT 9.690 34.190 10.155 34.635 ;
        RECT 11.160 34.590 11.390 34.635 ;
        RECT 11.665 34.540 12.110 35.160 ;
        RECT 10.665 34.095 11.120 34.360 ;
        RECT 11.620 34.175 12.110 34.540 ;
        RECT 12.800 35.670 13.285 36.000 ;
        RECT 13.690 35.690 14.225 36.010 ;
        RECT 14.715 35.670 15.220 36.005 ;
        RECT 12.800 34.865 13.245 35.670 ;
        RECT 13.535 35.390 13.765 35.435 ;
        RECT 14.775 35.390 15.220 35.670 ;
        RECT 13.535 35.160 15.220 35.390 ;
        RECT 13.535 35.095 13.765 35.160 ;
        RECT 14.270 34.865 14.500 34.930 ;
        RECT 12.800 34.635 14.500 34.865 ;
        RECT 12.800 34.190 13.265 34.635 ;
        RECT 14.270 34.590 14.500 34.635 ;
        RECT 14.775 34.540 15.220 35.160 ;
        RECT 13.775 34.095 14.230 34.360 ;
        RECT 14.730 34.175 15.220 34.540 ;
        RECT 15.910 35.670 16.395 36.000 ;
        RECT 16.800 35.690 17.335 36.010 ;
        RECT 17.825 35.670 18.330 36.005 ;
        RECT 15.910 34.865 16.355 35.670 ;
        RECT 16.645 35.390 16.875 35.435 ;
        RECT 17.885 35.390 18.330 35.670 ;
        RECT 16.645 35.160 18.330 35.390 ;
        RECT 16.645 35.095 16.875 35.160 ;
        RECT 17.380 34.865 17.610 34.930 ;
        RECT 15.910 34.635 17.610 34.865 ;
        RECT 15.910 34.190 16.375 34.635 ;
        RECT 17.380 34.590 17.610 34.635 ;
        RECT 17.885 34.540 18.330 35.160 ;
        RECT 16.885 34.095 17.340 34.360 ;
        RECT 17.840 34.175 18.330 34.540 ;
        RECT 19.020 35.670 19.505 36.000 ;
        RECT 19.910 35.690 20.445 36.010 ;
        RECT 20.935 35.670 21.440 36.005 ;
        RECT 19.020 34.865 19.465 35.670 ;
        RECT 19.755 35.390 19.985 35.435 ;
        RECT 20.995 35.390 21.440 35.670 ;
        RECT 19.755 35.160 21.440 35.390 ;
        RECT 19.755 35.095 19.985 35.160 ;
        RECT 20.490 34.865 20.720 34.930 ;
        RECT 19.020 34.635 20.720 34.865 ;
        RECT 19.020 34.190 19.485 34.635 ;
        RECT 20.490 34.590 20.720 34.635 ;
        RECT 20.995 34.540 21.440 35.160 ;
        RECT 19.995 34.095 20.450 34.360 ;
        RECT 20.950 34.175 21.440 34.540 ;
        RECT 22.130 35.670 22.615 36.000 ;
        RECT 23.020 35.690 23.555 36.010 ;
        RECT 24.045 35.670 24.550 36.005 ;
        RECT 22.130 34.865 22.575 35.670 ;
        RECT 22.865 35.390 23.095 35.435 ;
        RECT 24.105 35.390 24.550 35.670 ;
        RECT 24.950 35.390 25.555 35.955 ;
        RECT 22.865 35.160 24.550 35.390 ;
        RECT 22.865 35.095 23.095 35.160 ;
        RECT 23.600 34.865 23.830 34.930 ;
        RECT 22.130 34.635 23.830 34.865 ;
        RECT 22.130 34.190 22.595 34.635 ;
        RECT 23.600 34.590 23.830 34.635 ;
        RECT 24.105 34.540 24.550 35.160 ;
        RECT 23.105 34.095 23.560 34.360 ;
        RECT 24.060 34.175 24.550 34.540 ;
        RECT 24.920 34.170 25.525 34.735 ;
        RECT 0.000 33.385 0.390 33.820 ;
        RECT 0.610 32.925 1.000 33.305 ;
        RECT 1.435 32.880 1.700 34.095 ;
        RECT 3.110 33.385 3.500 33.820 ;
        RECT 2.240 32.925 2.630 33.305 ;
        RECT 3.720 32.925 4.110 33.305 ;
        RECT 4.545 32.880 4.810 34.095 ;
        RECT 6.220 33.385 6.610 33.820 ;
        RECT 5.350 32.925 5.740 33.305 ;
        RECT 6.830 32.925 7.220 33.305 ;
        RECT 7.655 32.880 7.920 34.095 ;
        RECT 9.330 33.385 9.720 33.820 ;
        RECT 8.460 32.925 8.850 33.305 ;
        RECT 9.940 32.925 10.330 33.305 ;
        RECT 10.765 32.880 11.030 34.095 ;
        RECT 12.440 33.385 12.830 33.820 ;
        RECT 11.570 32.925 11.960 33.305 ;
        RECT 13.050 32.925 13.440 33.305 ;
        RECT 13.875 32.880 14.140 34.095 ;
        RECT 15.550 33.385 15.940 33.820 ;
        RECT 14.680 32.925 15.070 33.305 ;
        RECT 16.160 32.925 16.550 33.305 ;
        RECT 16.985 32.880 17.250 34.095 ;
        RECT 18.660 33.385 19.050 33.820 ;
        RECT 17.790 32.925 18.180 33.305 ;
        RECT 19.270 32.925 19.660 33.305 ;
        RECT 20.095 32.880 20.360 34.095 ;
        RECT 21.770 33.385 22.160 33.820 ;
        RECT 20.900 32.925 21.290 33.305 ;
        RECT 22.380 32.925 22.770 33.305 ;
        RECT 23.205 32.880 23.470 34.095 ;
        RECT 24.010 32.925 24.400 33.305 ;
        RECT 1.435 32.645 2.005 32.880 ;
        RECT 4.545 32.645 5.115 32.880 ;
        RECT 7.655 32.645 8.225 32.880 ;
        RECT 10.765 32.645 11.335 32.880 ;
        RECT 13.875 32.645 14.445 32.880 ;
        RECT 16.985 32.645 17.555 32.880 ;
        RECT 20.095 32.645 20.665 32.880 ;
        RECT 23.205 32.645 23.775 32.880 ;
        RECT 1.710 32.465 2.005 32.645 ;
        RECT 4.820 32.465 5.115 32.645 ;
        RECT 7.930 32.465 8.225 32.645 ;
        RECT 11.040 32.465 11.335 32.645 ;
        RECT 14.150 32.465 14.445 32.645 ;
        RECT 17.260 32.465 17.555 32.645 ;
        RECT 20.370 32.465 20.665 32.645 ;
        RECT 23.480 32.465 23.775 32.645 ;
        RECT 0.185 31.245 0.545 32.415 ;
        RECT 1.025 31.820 1.390 32.415 ;
        RECT 1.710 32.105 2.070 32.465 ;
        RECT 2.550 32.165 2.910 32.400 ;
        RECT 2.575 31.820 2.910 32.165 ;
        RECT 1.025 31.575 2.910 31.820 ;
        RECT 1.025 31.495 2.670 31.575 ;
        RECT 0.185 30.800 1.790 31.245 ;
        RECT 2.300 30.805 2.670 31.495 ;
        RECT 3.295 31.245 3.655 32.415 ;
        RECT 4.135 31.820 4.500 32.415 ;
        RECT 4.820 32.105 5.180 32.465 ;
        RECT 5.660 32.165 6.020 32.400 ;
        RECT 5.685 31.820 6.020 32.165 ;
        RECT 4.135 31.575 6.020 31.820 ;
        RECT 4.135 31.495 5.780 31.575 ;
        RECT 3.295 30.800 4.900 31.245 ;
        RECT 5.410 30.805 5.780 31.495 ;
        RECT 6.405 31.245 6.765 32.415 ;
        RECT 7.245 31.820 7.610 32.415 ;
        RECT 7.930 32.105 8.290 32.465 ;
        RECT 8.770 32.165 9.130 32.400 ;
        RECT 8.795 31.820 9.130 32.165 ;
        RECT 7.245 31.575 9.130 31.820 ;
        RECT 7.245 31.495 8.890 31.575 ;
        RECT 6.405 30.800 8.010 31.245 ;
        RECT 8.520 30.805 8.890 31.495 ;
        RECT 9.515 31.245 9.875 32.415 ;
        RECT 10.355 31.820 10.720 32.415 ;
        RECT 11.040 32.105 11.400 32.465 ;
        RECT 11.880 32.165 12.240 32.400 ;
        RECT 11.905 31.820 12.240 32.165 ;
        RECT 10.355 31.575 12.240 31.820 ;
        RECT 10.355 31.495 12.000 31.575 ;
        RECT 9.515 30.800 11.120 31.245 ;
        RECT 11.630 30.805 12.000 31.495 ;
        RECT 12.625 31.245 12.985 32.415 ;
        RECT 13.465 31.820 13.830 32.415 ;
        RECT 14.150 32.105 14.510 32.465 ;
        RECT 14.990 32.165 15.350 32.400 ;
        RECT 15.015 31.820 15.350 32.165 ;
        RECT 13.465 31.575 15.350 31.820 ;
        RECT 13.465 31.495 15.110 31.575 ;
        RECT 12.625 30.800 14.230 31.245 ;
        RECT 14.740 30.805 15.110 31.495 ;
        RECT 15.735 31.245 16.095 32.415 ;
        RECT 16.575 31.820 16.940 32.415 ;
        RECT 17.260 32.105 17.620 32.465 ;
        RECT 18.100 32.165 18.460 32.400 ;
        RECT 18.125 31.820 18.460 32.165 ;
        RECT 16.575 31.575 18.460 31.820 ;
        RECT 16.575 31.495 18.220 31.575 ;
        RECT 15.735 30.800 17.340 31.245 ;
        RECT 17.850 30.805 18.220 31.495 ;
        RECT 18.845 31.245 19.205 32.415 ;
        RECT 19.685 31.820 20.050 32.415 ;
        RECT 20.370 32.105 20.730 32.465 ;
        RECT 21.210 32.165 21.570 32.400 ;
        RECT 21.235 31.820 21.570 32.165 ;
        RECT 19.685 31.575 21.570 31.820 ;
        RECT 19.685 31.495 21.330 31.575 ;
        RECT 18.845 30.800 20.450 31.245 ;
        RECT 20.960 30.805 21.330 31.495 ;
        RECT 21.955 31.245 22.315 32.415 ;
        RECT 22.795 31.820 23.160 32.415 ;
        RECT 23.480 32.105 23.840 32.465 ;
        RECT 24.320 32.165 24.680 32.400 ;
        RECT 24.345 31.820 24.680 32.165 ;
        RECT 22.795 31.575 24.680 31.820 ;
        RECT 22.795 31.495 24.440 31.575 ;
        RECT 21.955 30.800 23.560 31.245 ;
        RECT 24.070 30.805 24.440 31.495 ;
        RECT -0.685 29.825 0.130 30.390 ;
        RECT 0.360 30.190 0.845 30.520 ;
        RECT 1.250 30.210 1.785 30.530 ;
        RECT 2.275 30.190 2.780 30.525 ;
        RECT 0.360 29.385 0.805 30.190 ;
        RECT 1.095 29.910 1.325 29.955 ;
        RECT 2.335 29.910 2.780 30.190 ;
        RECT 1.095 29.680 2.780 29.910 ;
        RECT 1.095 29.615 1.325 29.680 ;
        RECT 1.830 29.385 2.060 29.450 ;
        RECT -0.685 28.690 0.000 29.255 ;
        RECT 0.360 29.155 2.060 29.385 ;
        RECT 0.360 28.710 0.825 29.155 ;
        RECT 1.830 29.110 2.060 29.155 ;
        RECT 2.335 29.060 2.780 29.680 ;
        RECT 1.335 28.615 1.790 28.880 ;
        RECT 2.290 28.695 2.780 29.060 ;
        RECT 3.470 30.190 3.955 30.520 ;
        RECT 4.360 30.210 4.895 30.530 ;
        RECT 5.385 30.190 5.890 30.525 ;
        RECT 3.470 29.385 3.915 30.190 ;
        RECT 4.205 29.910 4.435 29.955 ;
        RECT 5.445 29.910 5.890 30.190 ;
        RECT 4.205 29.680 5.890 29.910 ;
        RECT 4.205 29.615 4.435 29.680 ;
        RECT 4.940 29.385 5.170 29.450 ;
        RECT 3.470 29.155 5.170 29.385 ;
        RECT 3.470 28.710 3.935 29.155 ;
        RECT 4.940 29.110 5.170 29.155 ;
        RECT 5.445 29.060 5.890 29.680 ;
        RECT 4.445 28.615 4.900 28.880 ;
        RECT 5.400 28.695 5.890 29.060 ;
        RECT 6.580 30.190 7.065 30.520 ;
        RECT 7.470 30.210 8.005 30.530 ;
        RECT 8.495 30.190 9.000 30.525 ;
        RECT 6.580 29.385 7.025 30.190 ;
        RECT 7.315 29.910 7.545 29.955 ;
        RECT 8.555 29.910 9.000 30.190 ;
        RECT 7.315 29.680 9.000 29.910 ;
        RECT 7.315 29.615 7.545 29.680 ;
        RECT 8.050 29.385 8.280 29.450 ;
        RECT 6.580 29.155 8.280 29.385 ;
        RECT 6.580 28.710 7.045 29.155 ;
        RECT 8.050 29.110 8.280 29.155 ;
        RECT 8.555 29.060 9.000 29.680 ;
        RECT 7.555 28.615 8.010 28.880 ;
        RECT 8.510 28.695 9.000 29.060 ;
        RECT 9.690 30.190 10.175 30.520 ;
        RECT 10.580 30.210 11.115 30.530 ;
        RECT 11.605 30.190 12.110 30.525 ;
        RECT 9.690 29.385 10.135 30.190 ;
        RECT 10.425 29.910 10.655 29.955 ;
        RECT 11.665 29.910 12.110 30.190 ;
        RECT 10.425 29.680 12.110 29.910 ;
        RECT 10.425 29.615 10.655 29.680 ;
        RECT 11.160 29.385 11.390 29.450 ;
        RECT 9.690 29.155 11.390 29.385 ;
        RECT 9.690 28.710 10.155 29.155 ;
        RECT 11.160 29.110 11.390 29.155 ;
        RECT 11.665 29.060 12.110 29.680 ;
        RECT 10.665 28.615 11.120 28.880 ;
        RECT 11.620 28.695 12.110 29.060 ;
        RECT 12.800 30.190 13.285 30.520 ;
        RECT 13.690 30.210 14.225 30.530 ;
        RECT 14.715 30.190 15.220 30.525 ;
        RECT 12.800 29.385 13.245 30.190 ;
        RECT 13.535 29.910 13.765 29.955 ;
        RECT 14.775 29.910 15.220 30.190 ;
        RECT 13.535 29.680 15.220 29.910 ;
        RECT 13.535 29.615 13.765 29.680 ;
        RECT 14.270 29.385 14.500 29.450 ;
        RECT 12.800 29.155 14.500 29.385 ;
        RECT 12.800 28.710 13.265 29.155 ;
        RECT 14.270 29.110 14.500 29.155 ;
        RECT 14.775 29.060 15.220 29.680 ;
        RECT 13.775 28.615 14.230 28.880 ;
        RECT 14.730 28.695 15.220 29.060 ;
        RECT 15.910 30.190 16.395 30.520 ;
        RECT 16.800 30.210 17.335 30.530 ;
        RECT 17.825 30.190 18.330 30.525 ;
        RECT 15.910 29.385 16.355 30.190 ;
        RECT 16.645 29.910 16.875 29.955 ;
        RECT 17.885 29.910 18.330 30.190 ;
        RECT 16.645 29.680 18.330 29.910 ;
        RECT 16.645 29.615 16.875 29.680 ;
        RECT 17.380 29.385 17.610 29.450 ;
        RECT 15.910 29.155 17.610 29.385 ;
        RECT 15.910 28.710 16.375 29.155 ;
        RECT 17.380 29.110 17.610 29.155 ;
        RECT 17.885 29.060 18.330 29.680 ;
        RECT 16.885 28.615 17.340 28.880 ;
        RECT 17.840 28.695 18.330 29.060 ;
        RECT 19.020 30.190 19.505 30.520 ;
        RECT 19.910 30.210 20.445 30.530 ;
        RECT 20.935 30.190 21.440 30.525 ;
        RECT 19.020 29.385 19.465 30.190 ;
        RECT 19.755 29.910 19.985 29.955 ;
        RECT 20.995 29.910 21.440 30.190 ;
        RECT 19.755 29.680 21.440 29.910 ;
        RECT 19.755 29.615 19.985 29.680 ;
        RECT 20.490 29.385 20.720 29.450 ;
        RECT 19.020 29.155 20.720 29.385 ;
        RECT 19.020 28.710 19.485 29.155 ;
        RECT 20.490 29.110 20.720 29.155 ;
        RECT 20.995 29.060 21.440 29.680 ;
        RECT 19.995 28.615 20.450 28.880 ;
        RECT 20.950 28.695 21.440 29.060 ;
        RECT 22.130 30.190 22.615 30.520 ;
        RECT 23.020 30.210 23.555 30.530 ;
        RECT 24.045 30.190 24.550 30.525 ;
        RECT 22.130 29.385 22.575 30.190 ;
        RECT 22.865 29.910 23.095 29.955 ;
        RECT 24.105 29.910 24.550 30.190 ;
        RECT 24.950 29.910 25.555 30.475 ;
        RECT 22.865 29.680 24.550 29.910 ;
        RECT 22.865 29.615 23.095 29.680 ;
        RECT 23.600 29.385 23.830 29.450 ;
        RECT 22.130 29.155 23.830 29.385 ;
        RECT 22.130 28.710 22.595 29.155 ;
        RECT 23.600 29.110 23.830 29.155 ;
        RECT 24.105 29.060 24.550 29.680 ;
        RECT 23.105 28.615 23.560 28.880 ;
        RECT 24.060 28.695 24.550 29.060 ;
        RECT 24.920 28.690 25.525 29.255 ;
        RECT 0.000 27.905 0.390 28.340 ;
        RECT 0.610 27.445 1.000 27.825 ;
        RECT 1.435 27.400 1.700 28.615 ;
        RECT 3.110 27.905 3.500 28.340 ;
        RECT 2.240 27.445 2.630 27.825 ;
        RECT 3.720 27.445 4.110 27.825 ;
        RECT 4.545 27.400 4.810 28.615 ;
        RECT 6.220 27.905 6.610 28.340 ;
        RECT 5.350 27.445 5.740 27.825 ;
        RECT 6.830 27.445 7.220 27.825 ;
        RECT 7.655 27.400 7.920 28.615 ;
        RECT 9.330 27.905 9.720 28.340 ;
        RECT 8.460 27.445 8.850 27.825 ;
        RECT 9.940 27.445 10.330 27.825 ;
        RECT 10.765 27.400 11.030 28.615 ;
        RECT 12.440 27.905 12.830 28.340 ;
        RECT 11.570 27.445 11.960 27.825 ;
        RECT 13.050 27.445 13.440 27.825 ;
        RECT 13.875 27.400 14.140 28.615 ;
        RECT 15.550 27.905 15.940 28.340 ;
        RECT 14.680 27.445 15.070 27.825 ;
        RECT 16.160 27.445 16.550 27.825 ;
        RECT 16.985 27.400 17.250 28.615 ;
        RECT 18.660 27.905 19.050 28.340 ;
        RECT 17.790 27.445 18.180 27.825 ;
        RECT 19.270 27.445 19.660 27.825 ;
        RECT 20.095 27.400 20.360 28.615 ;
        RECT 21.770 27.905 22.160 28.340 ;
        RECT 20.900 27.445 21.290 27.825 ;
        RECT 22.380 27.445 22.770 27.825 ;
        RECT 23.205 27.400 23.470 28.615 ;
        RECT 24.010 27.445 24.400 27.825 ;
        RECT 1.435 27.165 2.005 27.400 ;
        RECT 4.545 27.165 5.115 27.400 ;
        RECT 7.655 27.165 8.225 27.400 ;
        RECT 10.765 27.165 11.335 27.400 ;
        RECT 13.875 27.165 14.445 27.400 ;
        RECT 16.985 27.165 17.555 27.400 ;
        RECT 20.095 27.165 20.665 27.400 ;
        RECT 23.205 27.165 23.775 27.400 ;
        RECT 1.710 26.985 2.005 27.165 ;
        RECT 4.820 26.985 5.115 27.165 ;
        RECT 7.930 26.985 8.225 27.165 ;
        RECT 11.040 26.985 11.335 27.165 ;
        RECT 14.150 26.985 14.445 27.165 ;
        RECT 17.260 26.985 17.555 27.165 ;
        RECT 20.370 26.985 20.665 27.165 ;
        RECT 23.480 26.985 23.775 27.165 ;
        RECT 0.185 25.765 0.545 26.935 ;
        RECT 1.025 26.340 1.390 26.935 ;
        RECT 1.710 26.625 2.070 26.985 ;
        RECT 2.550 26.685 2.910 26.920 ;
        RECT 2.575 26.340 2.910 26.685 ;
        RECT 1.025 26.095 2.910 26.340 ;
        RECT 1.025 26.015 2.670 26.095 ;
        RECT 0.185 25.320 1.790 25.765 ;
        RECT 2.300 25.325 2.670 26.015 ;
        RECT 3.295 25.765 3.655 26.935 ;
        RECT 4.135 26.340 4.500 26.935 ;
        RECT 4.820 26.625 5.180 26.985 ;
        RECT 5.660 26.685 6.020 26.920 ;
        RECT 5.685 26.340 6.020 26.685 ;
        RECT 4.135 26.095 6.020 26.340 ;
        RECT 4.135 26.015 5.780 26.095 ;
        RECT 3.295 25.320 4.900 25.765 ;
        RECT 5.410 25.325 5.780 26.015 ;
        RECT 6.405 25.765 6.765 26.935 ;
        RECT 7.245 26.340 7.610 26.935 ;
        RECT 7.930 26.625 8.290 26.985 ;
        RECT 8.770 26.685 9.130 26.920 ;
        RECT 8.795 26.340 9.130 26.685 ;
        RECT 7.245 26.095 9.130 26.340 ;
        RECT 7.245 26.015 8.890 26.095 ;
        RECT 6.405 25.320 8.010 25.765 ;
        RECT 8.520 25.325 8.890 26.015 ;
        RECT 9.515 25.765 9.875 26.935 ;
        RECT 10.355 26.340 10.720 26.935 ;
        RECT 11.040 26.625 11.400 26.985 ;
        RECT 11.880 26.685 12.240 26.920 ;
        RECT 11.905 26.340 12.240 26.685 ;
        RECT 10.355 26.095 12.240 26.340 ;
        RECT 10.355 26.015 12.000 26.095 ;
        RECT 9.515 25.320 11.120 25.765 ;
        RECT 11.630 25.325 12.000 26.015 ;
        RECT 12.625 25.765 12.985 26.935 ;
        RECT 13.465 26.340 13.830 26.935 ;
        RECT 14.150 26.625 14.510 26.985 ;
        RECT 14.990 26.685 15.350 26.920 ;
        RECT 15.015 26.340 15.350 26.685 ;
        RECT 13.465 26.095 15.350 26.340 ;
        RECT 13.465 26.015 15.110 26.095 ;
        RECT 12.625 25.320 14.230 25.765 ;
        RECT 14.740 25.325 15.110 26.015 ;
        RECT 15.735 25.765 16.095 26.935 ;
        RECT 16.575 26.340 16.940 26.935 ;
        RECT 17.260 26.625 17.620 26.985 ;
        RECT 18.100 26.685 18.460 26.920 ;
        RECT 18.125 26.340 18.460 26.685 ;
        RECT 16.575 26.095 18.460 26.340 ;
        RECT 16.575 26.015 18.220 26.095 ;
        RECT 15.735 25.320 17.340 25.765 ;
        RECT 17.850 25.325 18.220 26.015 ;
        RECT 18.845 25.765 19.205 26.935 ;
        RECT 19.685 26.340 20.050 26.935 ;
        RECT 20.370 26.625 20.730 26.985 ;
        RECT 21.210 26.685 21.570 26.920 ;
        RECT 21.235 26.340 21.570 26.685 ;
        RECT 19.685 26.095 21.570 26.340 ;
        RECT 19.685 26.015 21.330 26.095 ;
        RECT 18.845 25.320 20.450 25.765 ;
        RECT 20.960 25.325 21.330 26.015 ;
        RECT 21.955 25.765 22.315 26.935 ;
        RECT 22.795 26.340 23.160 26.935 ;
        RECT 23.480 26.625 23.840 26.985 ;
        RECT 24.320 26.685 24.680 26.920 ;
        RECT 24.345 26.340 24.680 26.685 ;
        RECT 22.795 26.095 24.680 26.340 ;
        RECT 22.795 26.015 24.440 26.095 ;
        RECT 21.955 25.320 23.560 25.765 ;
        RECT 24.070 25.325 24.440 26.015 ;
        RECT -0.685 24.345 0.130 24.910 ;
        RECT 0.360 24.710 0.845 25.040 ;
        RECT 1.250 24.730 1.785 25.050 ;
        RECT 2.275 24.710 2.780 25.045 ;
        RECT 0.360 23.905 0.805 24.710 ;
        RECT 1.095 24.430 1.325 24.475 ;
        RECT 2.335 24.430 2.780 24.710 ;
        RECT 1.095 24.200 2.780 24.430 ;
        RECT 1.095 24.135 1.325 24.200 ;
        RECT 1.830 23.905 2.060 23.970 ;
        RECT -0.685 23.210 0.000 23.775 ;
        RECT 0.360 23.675 2.060 23.905 ;
        RECT 0.360 23.230 0.825 23.675 ;
        RECT 1.830 23.630 2.060 23.675 ;
        RECT 2.335 23.580 2.780 24.200 ;
        RECT 1.335 23.135 1.790 23.400 ;
        RECT 2.290 23.215 2.780 23.580 ;
        RECT 3.470 24.710 3.955 25.040 ;
        RECT 4.360 24.730 4.895 25.050 ;
        RECT 5.385 24.710 5.890 25.045 ;
        RECT 3.470 23.905 3.915 24.710 ;
        RECT 4.205 24.430 4.435 24.475 ;
        RECT 5.445 24.430 5.890 24.710 ;
        RECT 4.205 24.200 5.890 24.430 ;
        RECT 4.205 24.135 4.435 24.200 ;
        RECT 4.940 23.905 5.170 23.970 ;
        RECT 3.470 23.675 5.170 23.905 ;
        RECT 3.470 23.230 3.935 23.675 ;
        RECT 4.940 23.630 5.170 23.675 ;
        RECT 5.445 23.580 5.890 24.200 ;
        RECT 4.445 23.135 4.900 23.400 ;
        RECT 5.400 23.215 5.890 23.580 ;
        RECT 6.580 24.710 7.065 25.040 ;
        RECT 7.470 24.730 8.005 25.050 ;
        RECT 8.495 24.710 9.000 25.045 ;
        RECT 6.580 23.905 7.025 24.710 ;
        RECT 7.315 24.430 7.545 24.475 ;
        RECT 8.555 24.430 9.000 24.710 ;
        RECT 7.315 24.200 9.000 24.430 ;
        RECT 7.315 24.135 7.545 24.200 ;
        RECT 8.050 23.905 8.280 23.970 ;
        RECT 6.580 23.675 8.280 23.905 ;
        RECT 6.580 23.230 7.045 23.675 ;
        RECT 8.050 23.630 8.280 23.675 ;
        RECT 8.555 23.580 9.000 24.200 ;
        RECT 7.555 23.135 8.010 23.400 ;
        RECT 8.510 23.215 9.000 23.580 ;
        RECT 9.690 24.710 10.175 25.040 ;
        RECT 10.580 24.730 11.115 25.050 ;
        RECT 11.605 24.710 12.110 25.045 ;
        RECT 9.690 23.905 10.135 24.710 ;
        RECT 10.425 24.430 10.655 24.475 ;
        RECT 11.665 24.430 12.110 24.710 ;
        RECT 10.425 24.200 12.110 24.430 ;
        RECT 10.425 24.135 10.655 24.200 ;
        RECT 11.160 23.905 11.390 23.970 ;
        RECT 9.690 23.675 11.390 23.905 ;
        RECT 9.690 23.230 10.155 23.675 ;
        RECT 11.160 23.630 11.390 23.675 ;
        RECT 11.665 23.580 12.110 24.200 ;
        RECT 10.665 23.135 11.120 23.400 ;
        RECT 11.620 23.215 12.110 23.580 ;
        RECT 12.800 24.710 13.285 25.040 ;
        RECT 13.690 24.730 14.225 25.050 ;
        RECT 14.715 24.710 15.220 25.045 ;
        RECT 12.800 23.905 13.245 24.710 ;
        RECT 13.535 24.430 13.765 24.475 ;
        RECT 14.775 24.430 15.220 24.710 ;
        RECT 13.535 24.200 15.220 24.430 ;
        RECT 13.535 24.135 13.765 24.200 ;
        RECT 14.270 23.905 14.500 23.970 ;
        RECT 12.800 23.675 14.500 23.905 ;
        RECT 12.800 23.230 13.265 23.675 ;
        RECT 14.270 23.630 14.500 23.675 ;
        RECT 14.775 23.580 15.220 24.200 ;
        RECT 13.775 23.135 14.230 23.400 ;
        RECT 14.730 23.215 15.220 23.580 ;
        RECT 15.910 24.710 16.395 25.040 ;
        RECT 16.800 24.730 17.335 25.050 ;
        RECT 17.825 24.710 18.330 25.045 ;
        RECT 15.910 23.905 16.355 24.710 ;
        RECT 16.645 24.430 16.875 24.475 ;
        RECT 17.885 24.430 18.330 24.710 ;
        RECT 16.645 24.200 18.330 24.430 ;
        RECT 16.645 24.135 16.875 24.200 ;
        RECT 17.380 23.905 17.610 23.970 ;
        RECT 15.910 23.675 17.610 23.905 ;
        RECT 15.910 23.230 16.375 23.675 ;
        RECT 17.380 23.630 17.610 23.675 ;
        RECT 17.885 23.580 18.330 24.200 ;
        RECT 16.885 23.135 17.340 23.400 ;
        RECT 17.840 23.215 18.330 23.580 ;
        RECT 19.020 24.710 19.505 25.040 ;
        RECT 19.910 24.730 20.445 25.050 ;
        RECT 20.935 24.710 21.440 25.045 ;
        RECT 19.020 23.905 19.465 24.710 ;
        RECT 19.755 24.430 19.985 24.475 ;
        RECT 20.995 24.430 21.440 24.710 ;
        RECT 19.755 24.200 21.440 24.430 ;
        RECT 19.755 24.135 19.985 24.200 ;
        RECT 20.490 23.905 20.720 23.970 ;
        RECT 19.020 23.675 20.720 23.905 ;
        RECT 19.020 23.230 19.485 23.675 ;
        RECT 20.490 23.630 20.720 23.675 ;
        RECT 20.995 23.580 21.440 24.200 ;
        RECT 19.995 23.135 20.450 23.400 ;
        RECT 20.950 23.215 21.440 23.580 ;
        RECT 22.130 24.710 22.615 25.040 ;
        RECT 23.020 24.730 23.555 25.050 ;
        RECT 24.045 24.710 24.550 25.045 ;
        RECT 22.130 23.905 22.575 24.710 ;
        RECT 22.865 24.430 23.095 24.475 ;
        RECT 24.105 24.430 24.550 24.710 ;
        RECT 24.950 24.430 25.555 24.995 ;
        RECT 22.865 24.200 24.550 24.430 ;
        RECT 22.865 24.135 23.095 24.200 ;
        RECT 23.600 23.905 23.830 23.970 ;
        RECT 22.130 23.675 23.830 23.905 ;
        RECT 22.130 23.230 22.595 23.675 ;
        RECT 23.600 23.630 23.830 23.675 ;
        RECT 24.105 23.580 24.550 24.200 ;
        RECT 23.105 23.135 23.560 23.400 ;
        RECT 24.060 23.215 24.550 23.580 ;
        RECT 24.920 23.210 25.525 23.775 ;
        RECT 0.000 22.425 0.390 22.860 ;
        RECT 0.610 21.965 1.000 22.345 ;
        RECT 1.435 21.920 1.700 23.135 ;
        RECT 3.110 22.425 3.500 22.860 ;
        RECT 2.240 21.965 2.630 22.345 ;
        RECT 3.720 21.965 4.110 22.345 ;
        RECT 4.545 21.920 4.810 23.135 ;
        RECT 6.220 22.425 6.610 22.860 ;
        RECT 5.350 21.965 5.740 22.345 ;
        RECT 6.830 21.965 7.220 22.345 ;
        RECT 7.655 21.920 7.920 23.135 ;
        RECT 9.330 22.425 9.720 22.860 ;
        RECT 8.460 21.965 8.850 22.345 ;
        RECT 9.940 21.965 10.330 22.345 ;
        RECT 10.765 21.920 11.030 23.135 ;
        RECT 12.440 22.425 12.830 22.860 ;
        RECT 11.570 21.965 11.960 22.345 ;
        RECT 13.050 21.965 13.440 22.345 ;
        RECT 13.875 21.920 14.140 23.135 ;
        RECT 15.550 22.425 15.940 22.860 ;
        RECT 14.680 21.965 15.070 22.345 ;
        RECT 16.160 21.965 16.550 22.345 ;
        RECT 16.985 21.920 17.250 23.135 ;
        RECT 18.660 22.425 19.050 22.860 ;
        RECT 17.790 21.965 18.180 22.345 ;
        RECT 19.270 21.965 19.660 22.345 ;
        RECT 20.095 21.920 20.360 23.135 ;
        RECT 21.770 22.425 22.160 22.860 ;
        RECT 20.900 21.965 21.290 22.345 ;
        RECT 22.380 21.965 22.770 22.345 ;
        RECT 23.205 21.920 23.470 23.135 ;
        RECT 24.010 21.965 24.400 22.345 ;
        RECT 1.435 21.685 2.005 21.920 ;
        RECT 4.545 21.685 5.115 21.920 ;
        RECT 7.655 21.685 8.225 21.920 ;
        RECT 10.765 21.685 11.335 21.920 ;
        RECT 13.875 21.685 14.445 21.920 ;
        RECT 16.985 21.685 17.555 21.920 ;
        RECT 20.095 21.685 20.665 21.920 ;
        RECT 23.205 21.685 23.775 21.920 ;
        RECT 1.710 21.505 2.005 21.685 ;
        RECT 4.820 21.505 5.115 21.685 ;
        RECT 7.930 21.505 8.225 21.685 ;
        RECT 11.040 21.505 11.335 21.685 ;
        RECT 14.150 21.505 14.445 21.685 ;
        RECT 17.260 21.505 17.555 21.685 ;
        RECT 20.370 21.505 20.665 21.685 ;
        RECT 23.480 21.505 23.775 21.685 ;
        RECT 0.185 20.285 0.545 21.455 ;
        RECT 1.025 20.860 1.390 21.455 ;
        RECT 1.710 21.145 2.070 21.505 ;
        RECT 2.550 21.205 2.910 21.440 ;
        RECT 2.575 20.860 2.910 21.205 ;
        RECT 1.025 20.615 2.910 20.860 ;
        RECT 1.025 20.535 2.670 20.615 ;
        RECT 0.185 19.840 1.790 20.285 ;
        RECT 2.300 19.845 2.670 20.535 ;
        RECT 3.295 20.285 3.655 21.455 ;
        RECT 4.135 20.860 4.500 21.455 ;
        RECT 4.820 21.145 5.180 21.505 ;
        RECT 5.660 21.205 6.020 21.440 ;
        RECT 5.685 20.860 6.020 21.205 ;
        RECT 4.135 20.615 6.020 20.860 ;
        RECT 4.135 20.535 5.780 20.615 ;
        RECT 3.295 19.840 4.900 20.285 ;
        RECT 5.410 19.845 5.780 20.535 ;
        RECT 6.405 20.285 6.765 21.455 ;
        RECT 7.245 20.860 7.610 21.455 ;
        RECT 7.930 21.145 8.290 21.505 ;
        RECT 8.770 21.205 9.130 21.440 ;
        RECT 8.795 20.860 9.130 21.205 ;
        RECT 7.245 20.615 9.130 20.860 ;
        RECT 7.245 20.535 8.890 20.615 ;
        RECT 6.405 19.840 8.010 20.285 ;
        RECT 8.520 19.845 8.890 20.535 ;
        RECT 9.515 20.285 9.875 21.455 ;
        RECT 10.355 20.860 10.720 21.455 ;
        RECT 11.040 21.145 11.400 21.505 ;
        RECT 11.880 21.205 12.240 21.440 ;
        RECT 11.905 20.860 12.240 21.205 ;
        RECT 10.355 20.615 12.240 20.860 ;
        RECT 10.355 20.535 12.000 20.615 ;
        RECT 9.515 19.840 11.120 20.285 ;
        RECT 11.630 19.845 12.000 20.535 ;
        RECT 12.625 20.285 12.985 21.455 ;
        RECT 13.465 20.860 13.830 21.455 ;
        RECT 14.150 21.145 14.510 21.505 ;
        RECT 14.990 21.205 15.350 21.440 ;
        RECT 15.015 20.860 15.350 21.205 ;
        RECT 13.465 20.615 15.350 20.860 ;
        RECT 13.465 20.535 15.110 20.615 ;
        RECT 12.625 19.840 14.230 20.285 ;
        RECT 14.740 19.845 15.110 20.535 ;
        RECT 15.735 20.285 16.095 21.455 ;
        RECT 16.575 20.860 16.940 21.455 ;
        RECT 17.260 21.145 17.620 21.505 ;
        RECT 18.100 21.205 18.460 21.440 ;
        RECT 18.125 20.860 18.460 21.205 ;
        RECT 16.575 20.615 18.460 20.860 ;
        RECT 16.575 20.535 18.220 20.615 ;
        RECT 15.735 19.840 17.340 20.285 ;
        RECT 17.850 19.845 18.220 20.535 ;
        RECT 18.845 20.285 19.205 21.455 ;
        RECT 19.685 20.860 20.050 21.455 ;
        RECT 20.370 21.145 20.730 21.505 ;
        RECT 21.210 21.205 21.570 21.440 ;
        RECT 21.235 20.860 21.570 21.205 ;
        RECT 19.685 20.615 21.570 20.860 ;
        RECT 19.685 20.535 21.330 20.615 ;
        RECT 18.845 19.840 20.450 20.285 ;
        RECT 20.960 19.845 21.330 20.535 ;
        RECT 21.955 20.285 22.315 21.455 ;
        RECT 22.795 20.860 23.160 21.455 ;
        RECT 23.480 21.145 23.840 21.505 ;
        RECT 24.320 21.205 24.680 21.440 ;
        RECT 24.345 20.860 24.680 21.205 ;
        RECT 22.795 20.615 24.680 20.860 ;
        RECT 22.795 20.535 24.440 20.615 ;
        RECT 21.955 19.840 23.560 20.285 ;
        RECT 24.070 19.845 24.440 20.535 ;
        RECT -0.685 18.865 0.130 19.430 ;
        RECT 0.360 19.230 0.845 19.560 ;
        RECT 1.250 19.250 1.785 19.570 ;
        RECT 2.275 19.230 2.780 19.565 ;
        RECT 0.360 18.425 0.805 19.230 ;
        RECT 1.095 18.950 1.325 18.995 ;
        RECT 2.335 18.950 2.780 19.230 ;
        RECT 1.095 18.720 2.780 18.950 ;
        RECT 1.095 18.655 1.325 18.720 ;
        RECT 1.830 18.425 2.060 18.490 ;
        RECT -0.685 17.730 0.005 18.295 ;
        RECT 0.360 18.195 2.060 18.425 ;
        RECT 0.360 17.750 0.825 18.195 ;
        RECT 1.830 18.150 2.060 18.195 ;
        RECT 2.335 18.100 2.780 18.720 ;
        RECT 1.335 17.655 1.790 17.920 ;
        RECT 2.290 17.735 2.780 18.100 ;
        RECT 3.470 19.230 3.955 19.560 ;
        RECT 4.360 19.250 4.895 19.570 ;
        RECT 5.385 19.230 5.890 19.565 ;
        RECT 3.470 18.425 3.915 19.230 ;
        RECT 4.205 18.950 4.435 18.995 ;
        RECT 5.445 18.950 5.890 19.230 ;
        RECT 4.205 18.720 5.890 18.950 ;
        RECT 4.205 18.655 4.435 18.720 ;
        RECT 4.940 18.425 5.170 18.490 ;
        RECT 3.470 18.195 5.170 18.425 ;
        RECT 3.470 17.750 3.935 18.195 ;
        RECT 4.940 18.150 5.170 18.195 ;
        RECT 5.445 18.100 5.890 18.720 ;
        RECT 4.445 17.655 4.900 17.920 ;
        RECT 5.400 17.735 5.890 18.100 ;
        RECT 6.580 19.230 7.065 19.560 ;
        RECT 7.470 19.250 8.005 19.570 ;
        RECT 8.495 19.230 9.000 19.565 ;
        RECT 6.580 18.425 7.025 19.230 ;
        RECT 7.315 18.950 7.545 18.995 ;
        RECT 8.555 18.950 9.000 19.230 ;
        RECT 7.315 18.720 9.000 18.950 ;
        RECT 7.315 18.655 7.545 18.720 ;
        RECT 8.050 18.425 8.280 18.490 ;
        RECT 6.580 18.195 8.280 18.425 ;
        RECT 6.580 17.750 7.045 18.195 ;
        RECT 8.050 18.150 8.280 18.195 ;
        RECT 8.555 18.100 9.000 18.720 ;
        RECT 7.555 17.655 8.010 17.920 ;
        RECT 8.510 17.735 9.000 18.100 ;
        RECT 9.690 19.230 10.175 19.560 ;
        RECT 10.580 19.250 11.115 19.570 ;
        RECT 11.605 19.230 12.110 19.565 ;
        RECT 9.690 18.425 10.135 19.230 ;
        RECT 10.425 18.950 10.655 18.995 ;
        RECT 11.665 18.950 12.110 19.230 ;
        RECT 10.425 18.720 12.110 18.950 ;
        RECT 10.425 18.655 10.655 18.720 ;
        RECT 11.160 18.425 11.390 18.490 ;
        RECT 9.690 18.195 11.390 18.425 ;
        RECT 9.690 17.750 10.155 18.195 ;
        RECT 11.160 18.150 11.390 18.195 ;
        RECT 11.665 18.100 12.110 18.720 ;
        RECT 10.665 17.655 11.120 17.920 ;
        RECT 11.620 17.735 12.110 18.100 ;
        RECT 12.800 19.230 13.285 19.560 ;
        RECT 13.690 19.250 14.225 19.570 ;
        RECT 14.715 19.230 15.220 19.565 ;
        RECT 12.800 18.425 13.245 19.230 ;
        RECT 13.535 18.950 13.765 18.995 ;
        RECT 14.775 18.950 15.220 19.230 ;
        RECT 13.535 18.720 15.220 18.950 ;
        RECT 13.535 18.655 13.765 18.720 ;
        RECT 14.270 18.425 14.500 18.490 ;
        RECT 12.800 18.195 14.500 18.425 ;
        RECT 12.800 17.750 13.265 18.195 ;
        RECT 14.270 18.150 14.500 18.195 ;
        RECT 14.775 18.100 15.220 18.720 ;
        RECT 13.775 17.655 14.230 17.920 ;
        RECT 14.730 17.735 15.220 18.100 ;
        RECT 15.910 19.230 16.395 19.560 ;
        RECT 16.800 19.250 17.335 19.570 ;
        RECT 17.825 19.230 18.330 19.565 ;
        RECT 15.910 18.425 16.355 19.230 ;
        RECT 16.645 18.950 16.875 18.995 ;
        RECT 17.885 18.950 18.330 19.230 ;
        RECT 16.645 18.720 18.330 18.950 ;
        RECT 16.645 18.655 16.875 18.720 ;
        RECT 17.380 18.425 17.610 18.490 ;
        RECT 15.910 18.195 17.610 18.425 ;
        RECT 15.910 17.750 16.375 18.195 ;
        RECT 17.380 18.150 17.610 18.195 ;
        RECT 17.885 18.100 18.330 18.720 ;
        RECT 16.885 17.655 17.340 17.920 ;
        RECT 17.840 17.735 18.330 18.100 ;
        RECT 19.020 19.230 19.505 19.560 ;
        RECT 19.910 19.250 20.445 19.570 ;
        RECT 20.935 19.230 21.440 19.565 ;
        RECT 19.020 18.425 19.465 19.230 ;
        RECT 19.755 18.950 19.985 18.995 ;
        RECT 20.995 18.950 21.440 19.230 ;
        RECT 19.755 18.720 21.440 18.950 ;
        RECT 19.755 18.655 19.985 18.720 ;
        RECT 20.490 18.425 20.720 18.490 ;
        RECT 19.020 18.195 20.720 18.425 ;
        RECT 19.020 17.750 19.485 18.195 ;
        RECT 20.490 18.150 20.720 18.195 ;
        RECT 20.995 18.100 21.440 18.720 ;
        RECT 19.995 17.655 20.450 17.920 ;
        RECT 20.950 17.735 21.440 18.100 ;
        RECT 22.130 19.230 22.615 19.560 ;
        RECT 23.020 19.250 23.555 19.570 ;
        RECT 24.045 19.230 24.550 19.565 ;
        RECT 22.130 18.425 22.575 19.230 ;
        RECT 22.865 18.950 23.095 18.995 ;
        RECT 24.105 18.950 24.550 19.230 ;
        RECT 24.950 18.950 25.555 19.515 ;
        RECT 22.865 18.720 24.550 18.950 ;
        RECT 22.865 18.655 23.095 18.720 ;
        RECT 23.600 18.425 23.830 18.490 ;
        RECT 22.130 18.195 23.830 18.425 ;
        RECT 22.130 17.750 22.595 18.195 ;
        RECT 23.600 18.150 23.830 18.195 ;
        RECT 24.105 18.100 24.550 18.720 ;
        RECT 23.105 17.655 23.560 17.920 ;
        RECT 24.060 17.735 24.550 18.100 ;
        RECT 24.920 17.730 25.525 18.295 ;
        RECT 0.000 16.945 0.390 17.380 ;
        RECT 0.610 16.485 1.000 16.865 ;
        RECT 1.435 16.440 1.700 17.655 ;
        RECT 3.110 16.945 3.500 17.380 ;
        RECT 2.240 16.485 2.630 16.865 ;
        RECT 3.720 16.485 4.110 16.865 ;
        RECT 4.545 16.440 4.810 17.655 ;
        RECT 6.220 16.945 6.610 17.380 ;
        RECT 5.350 16.485 5.740 16.865 ;
        RECT 6.830 16.485 7.220 16.865 ;
        RECT 7.655 16.440 7.920 17.655 ;
        RECT 9.330 16.945 9.720 17.380 ;
        RECT 8.460 16.485 8.850 16.865 ;
        RECT 9.940 16.485 10.330 16.865 ;
        RECT 10.765 16.440 11.030 17.655 ;
        RECT 12.440 16.945 12.830 17.380 ;
        RECT 11.570 16.485 11.960 16.865 ;
        RECT 13.050 16.485 13.440 16.865 ;
        RECT 13.875 16.440 14.140 17.655 ;
        RECT 15.550 16.945 15.940 17.380 ;
        RECT 14.680 16.485 15.070 16.865 ;
        RECT 16.160 16.485 16.550 16.865 ;
        RECT 16.985 16.440 17.250 17.655 ;
        RECT 18.660 16.945 19.050 17.380 ;
        RECT 17.790 16.485 18.180 16.865 ;
        RECT 19.270 16.485 19.660 16.865 ;
        RECT 20.095 16.440 20.360 17.655 ;
        RECT 21.770 16.945 22.160 17.380 ;
        RECT 20.900 16.485 21.290 16.865 ;
        RECT 22.380 16.485 22.770 16.865 ;
        RECT 23.205 16.440 23.470 17.655 ;
        RECT 24.010 16.485 24.400 16.865 ;
        RECT 1.435 16.205 2.005 16.440 ;
        RECT 4.545 16.205 5.115 16.440 ;
        RECT 7.655 16.205 8.225 16.440 ;
        RECT 10.765 16.205 11.335 16.440 ;
        RECT 13.875 16.205 14.445 16.440 ;
        RECT 16.985 16.205 17.555 16.440 ;
        RECT 20.095 16.205 20.665 16.440 ;
        RECT 23.205 16.205 23.775 16.440 ;
        RECT 1.710 16.025 2.005 16.205 ;
        RECT 4.820 16.025 5.115 16.205 ;
        RECT 7.930 16.025 8.225 16.205 ;
        RECT 11.040 16.025 11.335 16.205 ;
        RECT 14.150 16.025 14.445 16.205 ;
        RECT 17.260 16.025 17.555 16.205 ;
        RECT 20.370 16.025 20.665 16.205 ;
        RECT 23.480 16.025 23.775 16.205 ;
        RECT 0.185 14.805 0.545 15.975 ;
        RECT 1.025 15.380 1.390 15.975 ;
        RECT 1.710 15.665 2.070 16.025 ;
        RECT 2.550 15.725 2.910 15.960 ;
        RECT 2.575 15.380 2.910 15.725 ;
        RECT 1.025 15.135 2.910 15.380 ;
        RECT 1.025 15.055 2.670 15.135 ;
        RECT 0.185 14.360 1.790 14.805 ;
        RECT 2.300 14.365 2.670 15.055 ;
        RECT 3.295 14.805 3.655 15.975 ;
        RECT 4.135 15.380 4.500 15.975 ;
        RECT 4.820 15.665 5.180 16.025 ;
        RECT 5.660 15.725 6.020 15.960 ;
        RECT 5.685 15.380 6.020 15.725 ;
        RECT 4.135 15.135 6.020 15.380 ;
        RECT 4.135 15.055 5.780 15.135 ;
        RECT 3.295 14.360 4.900 14.805 ;
        RECT 5.410 14.365 5.780 15.055 ;
        RECT 6.405 14.805 6.765 15.975 ;
        RECT 7.245 15.380 7.610 15.975 ;
        RECT 7.930 15.665 8.290 16.025 ;
        RECT 8.770 15.725 9.130 15.960 ;
        RECT 8.795 15.380 9.130 15.725 ;
        RECT 7.245 15.135 9.130 15.380 ;
        RECT 7.245 15.055 8.890 15.135 ;
        RECT 6.405 14.360 8.010 14.805 ;
        RECT 8.520 14.365 8.890 15.055 ;
        RECT 9.515 14.805 9.875 15.975 ;
        RECT 10.355 15.380 10.720 15.975 ;
        RECT 11.040 15.665 11.400 16.025 ;
        RECT 11.880 15.725 12.240 15.960 ;
        RECT 11.905 15.380 12.240 15.725 ;
        RECT 10.355 15.135 12.240 15.380 ;
        RECT 10.355 15.055 12.000 15.135 ;
        RECT 9.515 14.360 11.120 14.805 ;
        RECT 11.630 14.365 12.000 15.055 ;
        RECT 12.625 14.805 12.985 15.975 ;
        RECT 13.465 15.380 13.830 15.975 ;
        RECT 14.150 15.665 14.510 16.025 ;
        RECT 14.990 15.725 15.350 15.960 ;
        RECT 15.015 15.380 15.350 15.725 ;
        RECT 13.465 15.135 15.350 15.380 ;
        RECT 13.465 15.055 15.110 15.135 ;
        RECT 12.625 14.360 14.230 14.805 ;
        RECT 14.740 14.365 15.110 15.055 ;
        RECT 15.735 14.805 16.095 15.975 ;
        RECT 16.575 15.380 16.940 15.975 ;
        RECT 17.260 15.665 17.620 16.025 ;
        RECT 18.100 15.725 18.460 15.960 ;
        RECT 18.125 15.380 18.460 15.725 ;
        RECT 16.575 15.135 18.460 15.380 ;
        RECT 16.575 15.055 18.220 15.135 ;
        RECT 15.735 14.360 17.340 14.805 ;
        RECT 17.850 14.365 18.220 15.055 ;
        RECT 18.845 14.805 19.205 15.975 ;
        RECT 19.685 15.380 20.050 15.975 ;
        RECT 20.370 15.665 20.730 16.025 ;
        RECT 21.210 15.725 21.570 15.960 ;
        RECT 21.235 15.380 21.570 15.725 ;
        RECT 19.685 15.135 21.570 15.380 ;
        RECT 19.685 15.055 21.330 15.135 ;
        RECT 18.845 14.360 20.450 14.805 ;
        RECT 20.960 14.365 21.330 15.055 ;
        RECT 21.955 14.805 22.315 15.975 ;
        RECT 22.795 15.380 23.160 15.975 ;
        RECT 23.480 15.665 23.840 16.025 ;
        RECT 24.320 15.725 24.680 15.960 ;
        RECT 24.345 15.380 24.680 15.725 ;
        RECT 22.795 15.135 24.680 15.380 ;
        RECT 22.795 15.055 24.440 15.135 ;
        RECT 21.955 14.360 23.560 14.805 ;
        RECT 24.070 14.365 24.440 15.055 ;
        RECT -0.685 13.390 0.130 13.955 ;
        RECT 0.360 13.750 0.845 14.080 ;
        RECT 1.250 13.770 1.785 14.090 ;
        RECT 2.275 13.750 2.780 14.085 ;
        RECT 0.360 12.945 0.805 13.750 ;
        RECT 1.095 13.470 1.325 13.515 ;
        RECT 2.335 13.470 2.780 13.750 ;
        RECT 1.095 13.240 2.780 13.470 ;
        RECT 1.095 13.175 1.325 13.240 ;
        RECT 1.830 12.945 2.060 13.010 ;
        RECT -0.685 12.250 0.005 12.815 ;
        RECT 0.360 12.715 2.060 12.945 ;
        RECT 0.360 12.270 0.825 12.715 ;
        RECT 1.830 12.670 2.060 12.715 ;
        RECT 2.335 12.620 2.780 13.240 ;
        RECT 1.335 12.175 1.790 12.440 ;
        RECT 2.290 12.255 2.780 12.620 ;
        RECT 3.470 13.750 3.955 14.080 ;
        RECT 4.360 13.770 4.895 14.090 ;
        RECT 5.385 13.750 5.890 14.085 ;
        RECT 3.470 12.945 3.915 13.750 ;
        RECT 4.205 13.470 4.435 13.515 ;
        RECT 5.445 13.470 5.890 13.750 ;
        RECT 4.205 13.240 5.890 13.470 ;
        RECT 4.205 13.175 4.435 13.240 ;
        RECT 4.940 12.945 5.170 13.010 ;
        RECT 3.470 12.715 5.170 12.945 ;
        RECT 3.470 12.270 3.935 12.715 ;
        RECT 4.940 12.670 5.170 12.715 ;
        RECT 5.445 12.620 5.890 13.240 ;
        RECT 4.445 12.175 4.900 12.440 ;
        RECT 5.400 12.255 5.890 12.620 ;
        RECT 6.580 13.750 7.065 14.080 ;
        RECT 7.470 13.770 8.005 14.090 ;
        RECT 8.495 13.750 9.000 14.085 ;
        RECT 6.580 12.945 7.025 13.750 ;
        RECT 7.315 13.470 7.545 13.515 ;
        RECT 8.555 13.470 9.000 13.750 ;
        RECT 7.315 13.240 9.000 13.470 ;
        RECT 7.315 13.175 7.545 13.240 ;
        RECT 8.050 12.945 8.280 13.010 ;
        RECT 6.580 12.715 8.280 12.945 ;
        RECT 6.580 12.270 7.045 12.715 ;
        RECT 8.050 12.670 8.280 12.715 ;
        RECT 8.555 12.620 9.000 13.240 ;
        RECT 7.555 12.175 8.010 12.440 ;
        RECT 8.510 12.255 9.000 12.620 ;
        RECT 9.690 13.750 10.175 14.080 ;
        RECT 10.580 13.770 11.115 14.090 ;
        RECT 11.605 13.750 12.110 14.085 ;
        RECT 9.690 12.945 10.135 13.750 ;
        RECT 10.425 13.470 10.655 13.515 ;
        RECT 11.665 13.470 12.110 13.750 ;
        RECT 10.425 13.240 12.110 13.470 ;
        RECT 10.425 13.175 10.655 13.240 ;
        RECT 11.160 12.945 11.390 13.010 ;
        RECT 9.690 12.715 11.390 12.945 ;
        RECT 9.690 12.270 10.155 12.715 ;
        RECT 11.160 12.670 11.390 12.715 ;
        RECT 11.665 12.620 12.110 13.240 ;
        RECT 10.665 12.175 11.120 12.440 ;
        RECT 11.620 12.255 12.110 12.620 ;
        RECT 12.800 13.750 13.285 14.080 ;
        RECT 13.690 13.770 14.225 14.090 ;
        RECT 14.715 13.750 15.220 14.085 ;
        RECT 12.800 12.945 13.245 13.750 ;
        RECT 13.535 13.470 13.765 13.515 ;
        RECT 14.775 13.470 15.220 13.750 ;
        RECT 13.535 13.240 15.220 13.470 ;
        RECT 13.535 13.175 13.765 13.240 ;
        RECT 14.270 12.945 14.500 13.010 ;
        RECT 12.800 12.715 14.500 12.945 ;
        RECT 12.800 12.270 13.265 12.715 ;
        RECT 14.270 12.670 14.500 12.715 ;
        RECT 14.775 12.620 15.220 13.240 ;
        RECT 13.775 12.175 14.230 12.440 ;
        RECT 14.730 12.255 15.220 12.620 ;
        RECT 15.910 13.750 16.395 14.080 ;
        RECT 16.800 13.770 17.335 14.090 ;
        RECT 17.825 13.750 18.330 14.085 ;
        RECT 15.910 12.945 16.355 13.750 ;
        RECT 16.645 13.470 16.875 13.515 ;
        RECT 17.885 13.470 18.330 13.750 ;
        RECT 16.645 13.240 18.330 13.470 ;
        RECT 16.645 13.175 16.875 13.240 ;
        RECT 17.380 12.945 17.610 13.010 ;
        RECT 15.910 12.715 17.610 12.945 ;
        RECT 15.910 12.270 16.375 12.715 ;
        RECT 17.380 12.670 17.610 12.715 ;
        RECT 17.885 12.620 18.330 13.240 ;
        RECT 16.885 12.175 17.340 12.440 ;
        RECT 17.840 12.255 18.330 12.620 ;
        RECT 19.020 13.750 19.505 14.080 ;
        RECT 19.910 13.770 20.445 14.090 ;
        RECT 20.935 13.750 21.440 14.085 ;
        RECT 19.020 12.945 19.465 13.750 ;
        RECT 19.755 13.470 19.985 13.515 ;
        RECT 20.995 13.470 21.440 13.750 ;
        RECT 19.755 13.240 21.440 13.470 ;
        RECT 19.755 13.175 19.985 13.240 ;
        RECT 20.490 12.945 20.720 13.010 ;
        RECT 19.020 12.715 20.720 12.945 ;
        RECT 19.020 12.270 19.485 12.715 ;
        RECT 20.490 12.670 20.720 12.715 ;
        RECT 20.995 12.620 21.440 13.240 ;
        RECT 19.995 12.175 20.450 12.440 ;
        RECT 20.950 12.255 21.440 12.620 ;
        RECT 22.130 13.750 22.615 14.080 ;
        RECT 23.020 13.770 23.555 14.090 ;
        RECT 24.045 13.750 24.550 14.085 ;
        RECT 22.130 12.945 22.575 13.750 ;
        RECT 22.865 13.470 23.095 13.515 ;
        RECT 24.105 13.470 24.550 13.750 ;
        RECT 24.950 13.470 25.555 14.035 ;
        RECT 22.865 13.240 24.550 13.470 ;
        RECT 22.865 13.175 23.095 13.240 ;
        RECT 23.600 12.945 23.830 13.010 ;
        RECT 22.130 12.715 23.830 12.945 ;
        RECT 22.130 12.270 22.595 12.715 ;
        RECT 23.600 12.670 23.830 12.715 ;
        RECT 24.105 12.620 24.550 13.240 ;
        RECT 23.105 12.175 23.560 12.440 ;
        RECT 24.060 12.255 24.550 12.620 ;
        RECT 24.920 12.250 25.525 12.815 ;
        RECT 0.000 11.465 0.390 11.900 ;
        RECT 0.610 11.005 1.000 11.385 ;
        RECT 1.435 10.960 1.700 12.175 ;
        RECT 3.110 11.465 3.500 11.900 ;
        RECT 2.240 11.005 2.630 11.385 ;
        RECT 3.720 11.005 4.110 11.385 ;
        RECT 4.545 10.960 4.810 12.175 ;
        RECT 6.220 11.465 6.610 11.900 ;
        RECT 5.350 11.005 5.740 11.385 ;
        RECT 6.830 11.005 7.220 11.385 ;
        RECT 7.655 10.960 7.920 12.175 ;
        RECT 9.330 11.465 9.720 11.900 ;
        RECT 8.460 11.005 8.850 11.385 ;
        RECT 9.940 11.005 10.330 11.385 ;
        RECT 10.765 10.960 11.030 12.175 ;
        RECT 12.440 11.465 12.830 11.900 ;
        RECT 11.570 11.005 11.960 11.385 ;
        RECT 13.050 11.005 13.440 11.385 ;
        RECT 13.875 10.960 14.140 12.175 ;
        RECT 15.550 11.465 15.940 11.900 ;
        RECT 14.680 11.005 15.070 11.385 ;
        RECT 16.160 11.005 16.550 11.385 ;
        RECT 16.985 10.960 17.250 12.175 ;
        RECT 18.660 11.465 19.050 11.900 ;
        RECT 17.790 11.005 18.180 11.385 ;
        RECT 19.270 11.005 19.660 11.385 ;
        RECT 20.095 10.960 20.360 12.175 ;
        RECT 21.770 11.465 22.160 11.900 ;
        RECT 20.900 11.005 21.290 11.385 ;
        RECT 22.380 11.005 22.770 11.385 ;
        RECT 23.205 10.960 23.470 12.175 ;
        RECT 24.010 11.005 24.400 11.385 ;
        RECT 1.435 10.725 2.005 10.960 ;
        RECT 4.545 10.725 5.115 10.960 ;
        RECT 7.655 10.725 8.225 10.960 ;
        RECT 10.765 10.725 11.335 10.960 ;
        RECT 13.875 10.725 14.445 10.960 ;
        RECT 16.985 10.725 17.555 10.960 ;
        RECT 20.095 10.725 20.665 10.960 ;
        RECT 23.205 10.725 23.775 10.960 ;
        RECT 1.710 10.545 2.005 10.725 ;
        RECT 4.820 10.545 5.115 10.725 ;
        RECT 7.930 10.545 8.225 10.725 ;
        RECT 11.040 10.545 11.335 10.725 ;
        RECT 14.150 10.545 14.445 10.725 ;
        RECT 17.260 10.545 17.555 10.725 ;
        RECT 20.370 10.545 20.665 10.725 ;
        RECT 23.480 10.545 23.775 10.725 ;
        RECT 0.185 9.325 0.545 10.495 ;
        RECT 1.025 9.900 1.390 10.495 ;
        RECT 1.710 10.185 2.070 10.545 ;
        RECT 2.550 10.245 2.910 10.480 ;
        RECT 2.575 9.900 2.910 10.245 ;
        RECT 1.025 9.655 2.910 9.900 ;
        RECT 1.025 9.575 2.670 9.655 ;
        RECT 0.185 8.880 1.790 9.325 ;
        RECT 2.300 8.885 2.670 9.575 ;
        RECT 3.295 9.325 3.655 10.495 ;
        RECT 4.135 9.900 4.500 10.495 ;
        RECT 4.820 10.185 5.180 10.545 ;
        RECT 5.660 10.245 6.020 10.480 ;
        RECT 5.685 9.900 6.020 10.245 ;
        RECT 4.135 9.655 6.020 9.900 ;
        RECT 4.135 9.575 5.780 9.655 ;
        RECT 3.295 8.880 4.900 9.325 ;
        RECT 5.410 8.885 5.780 9.575 ;
        RECT 6.405 9.325 6.765 10.495 ;
        RECT 7.245 9.900 7.610 10.495 ;
        RECT 7.930 10.185 8.290 10.545 ;
        RECT 8.770 10.245 9.130 10.480 ;
        RECT 8.795 9.900 9.130 10.245 ;
        RECT 7.245 9.655 9.130 9.900 ;
        RECT 7.245 9.575 8.890 9.655 ;
        RECT 6.405 8.880 8.010 9.325 ;
        RECT 8.520 8.885 8.890 9.575 ;
        RECT 9.515 9.325 9.875 10.495 ;
        RECT 10.355 9.900 10.720 10.495 ;
        RECT 11.040 10.185 11.400 10.545 ;
        RECT 11.880 10.245 12.240 10.480 ;
        RECT 11.905 9.900 12.240 10.245 ;
        RECT 10.355 9.655 12.240 9.900 ;
        RECT 10.355 9.575 12.000 9.655 ;
        RECT 9.515 8.880 11.120 9.325 ;
        RECT 11.630 8.885 12.000 9.575 ;
        RECT 12.625 9.325 12.985 10.495 ;
        RECT 13.465 9.900 13.830 10.495 ;
        RECT 14.150 10.185 14.510 10.545 ;
        RECT 14.990 10.245 15.350 10.480 ;
        RECT 15.015 9.900 15.350 10.245 ;
        RECT 13.465 9.655 15.350 9.900 ;
        RECT 13.465 9.575 15.110 9.655 ;
        RECT 12.625 8.880 14.230 9.325 ;
        RECT 14.740 8.885 15.110 9.575 ;
        RECT 15.735 9.325 16.095 10.495 ;
        RECT 16.575 9.900 16.940 10.495 ;
        RECT 17.260 10.185 17.620 10.545 ;
        RECT 18.100 10.245 18.460 10.480 ;
        RECT 18.125 9.900 18.460 10.245 ;
        RECT 16.575 9.655 18.460 9.900 ;
        RECT 16.575 9.575 18.220 9.655 ;
        RECT 15.735 8.880 17.340 9.325 ;
        RECT 17.850 8.885 18.220 9.575 ;
        RECT 18.845 9.325 19.205 10.495 ;
        RECT 19.685 9.900 20.050 10.495 ;
        RECT 20.370 10.185 20.730 10.545 ;
        RECT 21.210 10.245 21.570 10.480 ;
        RECT 21.235 9.900 21.570 10.245 ;
        RECT 19.685 9.655 21.570 9.900 ;
        RECT 19.685 9.575 21.330 9.655 ;
        RECT 18.845 8.880 20.450 9.325 ;
        RECT 20.960 8.885 21.330 9.575 ;
        RECT 21.955 9.325 22.315 10.495 ;
        RECT 22.795 9.900 23.160 10.495 ;
        RECT 23.480 10.185 23.840 10.545 ;
        RECT 24.320 10.245 24.680 10.480 ;
        RECT 24.345 9.900 24.680 10.245 ;
        RECT 22.795 9.655 24.680 9.900 ;
        RECT 22.795 9.575 24.440 9.655 ;
        RECT 21.955 8.880 23.560 9.325 ;
        RECT 24.070 8.885 24.440 9.575 ;
        RECT -0.685 7.905 0.130 8.470 ;
        RECT 0.360 8.270 0.845 8.600 ;
        RECT 1.250 8.290 1.785 8.610 ;
        RECT 2.275 8.270 2.780 8.605 ;
        RECT 0.360 7.465 0.805 8.270 ;
        RECT 1.095 7.990 1.325 8.035 ;
        RECT 2.335 7.990 2.780 8.270 ;
        RECT 1.095 7.760 2.780 7.990 ;
        RECT 1.095 7.695 1.325 7.760 ;
        RECT 1.830 7.465 2.060 7.530 ;
        RECT -0.685 6.770 0.005 7.335 ;
        RECT 0.360 7.235 2.060 7.465 ;
        RECT 0.360 6.790 0.825 7.235 ;
        RECT 1.830 7.190 2.060 7.235 ;
        RECT 2.335 7.140 2.780 7.760 ;
        RECT 1.335 6.695 1.790 6.960 ;
        RECT 2.290 6.775 2.780 7.140 ;
        RECT 3.470 8.270 3.955 8.600 ;
        RECT 4.360 8.290 4.895 8.610 ;
        RECT 5.385 8.270 5.890 8.605 ;
        RECT 3.470 7.465 3.915 8.270 ;
        RECT 4.205 7.990 4.435 8.035 ;
        RECT 5.445 7.990 5.890 8.270 ;
        RECT 4.205 7.760 5.890 7.990 ;
        RECT 4.205 7.695 4.435 7.760 ;
        RECT 4.940 7.465 5.170 7.530 ;
        RECT 3.470 7.235 5.170 7.465 ;
        RECT 3.470 6.790 3.935 7.235 ;
        RECT 4.940 7.190 5.170 7.235 ;
        RECT 5.445 7.140 5.890 7.760 ;
        RECT 4.445 6.695 4.900 6.960 ;
        RECT 5.400 6.775 5.890 7.140 ;
        RECT 6.580 8.270 7.065 8.600 ;
        RECT 7.470 8.290 8.005 8.610 ;
        RECT 8.495 8.270 9.000 8.605 ;
        RECT 6.580 7.465 7.025 8.270 ;
        RECT 7.315 7.990 7.545 8.035 ;
        RECT 8.555 7.990 9.000 8.270 ;
        RECT 7.315 7.760 9.000 7.990 ;
        RECT 7.315 7.695 7.545 7.760 ;
        RECT 8.050 7.465 8.280 7.530 ;
        RECT 6.580 7.235 8.280 7.465 ;
        RECT 6.580 6.790 7.045 7.235 ;
        RECT 8.050 7.190 8.280 7.235 ;
        RECT 8.555 7.140 9.000 7.760 ;
        RECT 7.555 6.695 8.010 6.960 ;
        RECT 8.510 6.775 9.000 7.140 ;
        RECT 9.690 8.270 10.175 8.600 ;
        RECT 10.580 8.290 11.115 8.610 ;
        RECT 11.605 8.270 12.110 8.605 ;
        RECT 9.690 7.465 10.135 8.270 ;
        RECT 10.425 7.990 10.655 8.035 ;
        RECT 11.665 7.990 12.110 8.270 ;
        RECT 10.425 7.760 12.110 7.990 ;
        RECT 10.425 7.695 10.655 7.760 ;
        RECT 11.160 7.465 11.390 7.530 ;
        RECT 9.690 7.235 11.390 7.465 ;
        RECT 9.690 6.790 10.155 7.235 ;
        RECT 11.160 7.190 11.390 7.235 ;
        RECT 11.665 7.140 12.110 7.760 ;
        RECT 10.665 6.695 11.120 6.960 ;
        RECT 11.620 6.775 12.110 7.140 ;
        RECT 12.800 8.270 13.285 8.600 ;
        RECT 13.690 8.290 14.225 8.610 ;
        RECT 14.715 8.270 15.220 8.605 ;
        RECT 12.800 7.465 13.245 8.270 ;
        RECT 13.535 7.990 13.765 8.035 ;
        RECT 14.775 7.990 15.220 8.270 ;
        RECT 13.535 7.760 15.220 7.990 ;
        RECT 13.535 7.695 13.765 7.760 ;
        RECT 14.270 7.465 14.500 7.530 ;
        RECT 12.800 7.235 14.500 7.465 ;
        RECT 12.800 6.790 13.265 7.235 ;
        RECT 14.270 7.190 14.500 7.235 ;
        RECT 14.775 7.140 15.220 7.760 ;
        RECT 13.775 6.695 14.230 6.960 ;
        RECT 14.730 6.775 15.220 7.140 ;
        RECT 15.910 8.270 16.395 8.600 ;
        RECT 16.800 8.290 17.335 8.610 ;
        RECT 17.825 8.270 18.330 8.605 ;
        RECT 15.910 7.465 16.355 8.270 ;
        RECT 16.645 7.990 16.875 8.035 ;
        RECT 17.885 7.990 18.330 8.270 ;
        RECT 16.645 7.760 18.330 7.990 ;
        RECT 16.645 7.695 16.875 7.760 ;
        RECT 17.380 7.465 17.610 7.530 ;
        RECT 15.910 7.235 17.610 7.465 ;
        RECT 15.910 6.790 16.375 7.235 ;
        RECT 17.380 7.190 17.610 7.235 ;
        RECT 17.885 7.140 18.330 7.760 ;
        RECT 16.885 6.695 17.340 6.960 ;
        RECT 17.840 6.775 18.330 7.140 ;
        RECT 19.020 8.270 19.505 8.600 ;
        RECT 19.910 8.290 20.445 8.610 ;
        RECT 20.935 8.270 21.440 8.605 ;
        RECT 19.020 7.465 19.465 8.270 ;
        RECT 19.755 7.990 19.985 8.035 ;
        RECT 20.995 7.990 21.440 8.270 ;
        RECT 19.755 7.760 21.440 7.990 ;
        RECT 19.755 7.695 19.985 7.760 ;
        RECT 20.490 7.465 20.720 7.530 ;
        RECT 19.020 7.235 20.720 7.465 ;
        RECT 19.020 6.790 19.485 7.235 ;
        RECT 20.490 7.190 20.720 7.235 ;
        RECT 20.995 7.140 21.440 7.760 ;
        RECT 19.995 6.695 20.450 6.960 ;
        RECT 20.950 6.775 21.440 7.140 ;
        RECT 22.130 8.270 22.615 8.600 ;
        RECT 23.020 8.290 23.555 8.610 ;
        RECT 24.045 8.270 24.550 8.605 ;
        RECT 22.130 7.465 22.575 8.270 ;
        RECT 22.865 7.990 23.095 8.035 ;
        RECT 24.105 7.990 24.550 8.270 ;
        RECT 24.950 7.990 25.555 8.555 ;
        RECT 22.865 7.760 24.550 7.990 ;
        RECT 22.865 7.695 23.095 7.760 ;
        RECT 23.600 7.465 23.830 7.530 ;
        RECT 22.130 7.235 23.830 7.465 ;
        RECT 22.130 6.790 22.595 7.235 ;
        RECT 23.600 7.190 23.830 7.235 ;
        RECT 24.105 7.140 24.550 7.760 ;
        RECT 23.105 6.695 23.560 6.960 ;
        RECT 24.060 6.775 24.550 7.140 ;
        RECT 24.920 6.770 25.525 7.335 ;
        RECT 0.000 5.985 0.390 6.420 ;
        RECT 0.610 5.525 1.000 5.905 ;
        RECT 1.435 5.480 1.700 6.695 ;
        RECT 3.110 5.985 3.500 6.420 ;
        RECT 2.240 5.525 2.630 5.905 ;
        RECT 3.720 5.525 4.110 5.905 ;
        RECT 4.545 5.480 4.810 6.695 ;
        RECT 6.220 5.985 6.610 6.420 ;
        RECT 5.350 5.525 5.740 5.905 ;
        RECT 6.830 5.525 7.220 5.905 ;
        RECT 7.655 5.480 7.920 6.695 ;
        RECT 9.330 5.985 9.720 6.420 ;
        RECT 8.460 5.525 8.850 5.905 ;
        RECT 9.940 5.525 10.330 5.905 ;
        RECT 10.765 5.480 11.030 6.695 ;
        RECT 12.440 5.985 12.830 6.420 ;
        RECT 11.570 5.525 11.960 5.905 ;
        RECT 13.050 5.525 13.440 5.905 ;
        RECT 13.875 5.480 14.140 6.695 ;
        RECT 15.550 5.985 15.940 6.420 ;
        RECT 14.680 5.525 15.070 5.905 ;
        RECT 16.160 5.525 16.550 5.905 ;
        RECT 16.985 5.480 17.250 6.695 ;
        RECT 18.660 5.985 19.050 6.420 ;
        RECT 17.790 5.525 18.180 5.905 ;
        RECT 19.270 5.525 19.660 5.905 ;
        RECT 20.095 5.480 20.360 6.695 ;
        RECT 21.770 5.985 22.160 6.420 ;
        RECT 20.900 5.525 21.290 5.905 ;
        RECT 22.380 5.525 22.770 5.905 ;
        RECT 23.205 5.480 23.470 6.695 ;
        RECT 24.010 5.525 24.400 5.905 ;
        RECT 1.435 5.245 2.005 5.480 ;
        RECT 4.545 5.245 5.115 5.480 ;
        RECT 7.655 5.245 8.225 5.480 ;
        RECT 10.765 5.245 11.335 5.480 ;
        RECT 13.875 5.245 14.445 5.480 ;
        RECT 16.985 5.245 17.555 5.480 ;
        RECT 20.095 5.245 20.665 5.480 ;
        RECT 23.205 5.245 23.775 5.480 ;
        RECT 1.710 5.065 2.005 5.245 ;
        RECT 4.820 5.065 5.115 5.245 ;
        RECT 7.930 5.065 8.225 5.245 ;
        RECT 11.040 5.065 11.335 5.245 ;
        RECT 14.150 5.065 14.445 5.245 ;
        RECT 17.260 5.065 17.555 5.245 ;
        RECT 20.370 5.065 20.665 5.245 ;
        RECT 23.480 5.065 23.775 5.245 ;
        RECT 0.185 3.845 0.545 5.015 ;
        RECT 1.025 4.420 1.390 5.015 ;
        RECT 1.710 4.705 2.070 5.065 ;
        RECT 2.550 4.765 2.910 5.000 ;
        RECT 2.575 4.420 2.910 4.765 ;
        RECT 1.025 4.175 2.910 4.420 ;
        RECT 1.025 4.095 2.670 4.175 ;
        RECT 0.185 3.400 1.790 3.845 ;
        RECT 2.300 3.405 2.670 4.095 ;
        RECT 3.295 3.845 3.655 5.015 ;
        RECT 4.135 4.420 4.500 5.015 ;
        RECT 4.820 4.705 5.180 5.065 ;
        RECT 5.660 4.765 6.020 5.000 ;
        RECT 5.685 4.420 6.020 4.765 ;
        RECT 4.135 4.175 6.020 4.420 ;
        RECT 4.135 4.095 5.780 4.175 ;
        RECT 3.295 3.400 4.900 3.845 ;
        RECT 5.410 3.405 5.780 4.095 ;
        RECT 6.405 3.845 6.765 5.015 ;
        RECT 7.245 4.420 7.610 5.015 ;
        RECT 7.930 4.705 8.290 5.065 ;
        RECT 8.770 4.765 9.130 5.000 ;
        RECT 8.795 4.420 9.130 4.765 ;
        RECT 7.245 4.175 9.130 4.420 ;
        RECT 7.245 4.095 8.890 4.175 ;
        RECT 6.405 3.400 8.010 3.845 ;
        RECT 8.520 3.405 8.890 4.095 ;
        RECT 9.515 3.845 9.875 5.015 ;
        RECT 10.355 4.420 10.720 5.015 ;
        RECT 11.040 4.705 11.400 5.065 ;
        RECT 11.880 4.765 12.240 5.000 ;
        RECT 11.905 4.420 12.240 4.765 ;
        RECT 10.355 4.175 12.240 4.420 ;
        RECT 10.355 4.095 12.000 4.175 ;
        RECT 9.515 3.400 11.120 3.845 ;
        RECT 11.630 3.405 12.000 4.095 ;
        RECT 12.625 3.845 12.985 5.015 ;
        RECT 13.465 4.420 13.830 5.015 ;
        RECT 14.150 4.705 14.510 5.065 ;
        RECT 14.990 4.765 15.350 5.000 ;
        RECT 15.015 4.420 15.350 4.765 ;
        RECT 13.465 4.175 15.350 4.420 ;
        RECT 13.465 4.095 15.110 4.175 ;
        RECT 12.625 3.400 14.230 3.845 ;
        RECT 14.740 3.405 15.110 4.095 ;
        RECT 15.735 3.845 16.095 5.015 ;
        RECT 16.575 4.420 16.940 5.015 ;
        RECT 17.260 4.705 17.620 5.065 ;
        RECT 18.100 4.765 18.460 5.000 ;
        RECT 18.125 4.420 18.460 4.765 ;
        RECT 16.575 4.175 18.460 4.420 ;
        RECT 16.575 4.095 18.220 4.175 ;
        RECT 15.735 3.400 17.340 3.845 ;
        RECT 17.850 3.405 18.220 4.095 ;
        RECT 18.845 3.845 19.205 5.015 ;
        RECT 19.685 4.420 20.050 5.015 ;
        RECT 20.370 4.705 20.730 5.065 ;
        RECT 21.210 4.765 21.570 5.000 ;
        RECT 21.235 4.420 21.570 4.765 ;
        RECT 19.685 4.175 21.570 4.420 ;
        RECT 19.685 4.095 21.330 4.175 ;
        RECT 18.845 3.400 20.450 3.845 ;
        RECT 20.960 3.405 21.330 4.095 ;
        RECT 21.955 3.845 22.315 5.015 ;
        RECT 22.795 4.420 23.160 5.015 ;
        RECT 23.480 4.705 23.840 5.065 ;
        RECT 24.320 4.765 24.680 5.000 ;
        RECT 24.345 4.420 24.680 4.765 ;
        RECT 22.795 4.175 24.680 4.420 ;
        RECT 22.795 4.095 24.440 4.175 ;
        RECT 21.955 3.400 23.560 3.845 ;
        RECT 24.070 3.405 24.440 4.095 ;
        RECT -0.685 2.470 0.130 3.035 ;
        RECT 0.360 2.790 0.845 3.120 ;
        RECT 1.250 2.810 1.785 3.130 ;
        RECT 2.275 2.790 2.780 3.125 ;
        RECT 0.360 1.985 0.805 2.790 ;
        RECT 1.095 2.510 1.325 2.555 ;
        RECT 2.335 2.510 2.780 2.790 ;
        RECT 1.095 2.280 2.780 2.510 ;
        RECT 1.095 2.215 1.325 2.280 ;
        RECT 1.830 1.985 2.060 2.050 ;
        RECT -0.685 1.290 0.050 1.855 ;
        RECT 0.360 1.755 2.060 1.985 ;
        RECT 0.360 1.310 0.825 1.755 ;
        RECT 1.830 1.710 2.060 1.755 ;
        RECT 2.335 1.660 2.780 2.280 ;
        RECT 1.335 1.215 1.790 1.480 ;
        RECT 2.290 1.295 2.780 1.660 ;
        RECT 3.470 2.790 3.955 3.120 ;
        RECT 4.360 2.810 4.895 3.130 ;
        RECT 5.385 2.790 5.890 3.125 ;
        RECT 3.470 1.985 3.915 2.790 ;
        RECT 4.205 2.510 4.435 2.555 ;
        RECT 5.445 2.510 5.890 2.790 ;
        RECT 4.205 2.280 5.890 2.510 ;
        RECT 4.205 2.215 4.435 2.280 ;
        RECT 4.940 1.985 5.170 2.050 ;
        RECT 3.470 1.755 5.170 1.985 ;
        RECT 3.470 1.310 3.935 1.755 ;
        RECT 4.940 1.710 5.170 1.755 ;
        RECT 5.445 1.660 5.890 2.280 ;
        RECT 4.445 1.215 4.900 1.480 ;
        RECT 5.400 1.295 5.890 1.660 ;
        RECT 6.580 2.790 7.065 3.120 ;
        RECT 7.470 2.810 8.005 3.130 ;
        RECT 8.495 2.790 9.000 3.125 ;
        RECT 6.580 1.985 7.025 2.790 ;
        RECT 7.315 2.510 7.545 2.555 ;
        RECT 8.555 2.510 9.000 2.790 ;
        RECT 7.315 2.280 9.000 2.510 ;
        RECT 7.315 2.215 7.545 2.280 ;
        RECT 8.050 1.985 8.280 2.050 ;
        RECT 6.580 1.755 8.280 1.985 ;
        RECT 6.580 1.310 7.045 1.755 ;
        RECT 8.050 1.710 8.280 1.755 ;
        RECT 8.555 1.660 9.000 2.280 ;
        RECT 7.555 1.215 8.010 1.480 ;
        RECT 8.510 1.295 9.000 1.660 ;
        RECT 9.690 2.790 10.175 3.120 ;
        RECT 10.580 2.810 11.115 3.130 ;
        RECT 11.605 2.790 12.110 3.125 ;
        RECT 9.690 1.985 10.135 2.790 ;
        RECT 10.425 2.510 10.655 2.555 ;
        RECT 11.665 2.510 12.110 2.790 ;
        RECT 10.425 2.280 12.110 2.510 ;
        RECT 10.425 2.215 10.655 2.280 ;
        RECT 11.160 1.985 11.390 2.050 ;
        RECT 9.690 1.755 11.390 1.985 ;
        RECT 9.690 1.310 10.155 1.755 ;
        RECT 11.160 1.710 11.390 1.755 ;
        RECT 11.665 1.660 12.110 2.280 ;
        RECT 10.665 1.215 11.120 1.480 ;
        RECT 11.620 1.295 12.110 1.660 ;
        RECT 12.800 2.790 13.285 3.120 ;
        RECT 13.690 2.810 14.225 3.130 ;
        RECT 14.715 2.790 15.220 3.125 ;
        RECT 12.800 1.985 13.245 2.790 ;
        RECT 13.535 2.510 13.765 2.555 ;
        RECT 14.775 2.510 15.220 2.790 ;
        RECT 13.535 2.280 15.220 2.510 ;
        RECT 13.535 2.215 13.765 2.280 ;
        RECT 14.270 1.985 14.500 2.050 ;
        RECT 12.800 1.755 14.500 1.985 ;
        RECT 12.800 1.310 13.265 1.755 ;
        RECT 14.270 1.710 14.500 1.755 ;
        RECT 14.775 1.660 15.220 2.280 ;
        RECT 13.775 1.215 14.230 1.480 ;
        RECT 14.730 1.295 15.220 1.660 ;
        RECT 15.910 2.790 16.395 3.120 ;
        RECT 16.800 2.810 17.335 3.130 ;
        RECT 17.825 2.790 18.330 3.125 ;
        RECT 15.910 1.985 16.355 2.790 ;
        RECT 16.645 2.510 16.875 2.555 ;
        RECT 17.885 2.510 18.330 2.790 ;
        RECT 16.645 2.280 18.330 2.510 ;
        RECT 16.645 2.215 16.875 2.280 ;
        RECT 17.380 1.985 17.610 2.050 ;
        RECT 15.910 1.755 17.610 1.985 ;
        RECT 15.910 1.310 16.375 1.755 ;
        RECT 17.380 1.710 17.610 1.755 ;
        RECT 17.885 1.660 18.330 2.280 ;
        RECT 16.885 1.215 17.340 1.480 ;
        RECT 17.840 1.295 18.330 1.660 ;
        RECT 19.020 2.790 19.505 3.120 ;
        RECT 19.910 2.810 20.445 3.130 ;
        RECT 20.935 2.790 21.440 3.125 ;
        RECT 19.020 1.985 19.465 2.790 ;
        RECT 19.755 2.510 19.985 2.555 ;
        RECT 20.995 2.510 21.440 2.790 ;
        RECT 19.755 2.280 21.440 2.510 ;
        RECT 19.755 2.215 19.985 2.280 ;
        RECT 20.490 1.985 20.720 2.050 ;
        RECT 19.020 1.755 20.720 1.985 ;
        RECT 19.020 1.310 19.485 1.755 ;
        RECT 20.490 1.710 20.720 1.755 ;
        RECT 20.995 1.660 21.440 2.280 ;
        RECT 19.995 1.215 20.450 1.480 ;
        RECT 20.950 1.295 21.440 1.660 ;
        RECT 22.130 2.790 22.615 3.120 ;
        RECT 23.020 2.810 23.555 3.130 ;
        RECT 24.045 2.790 24.550 3.125 ;
        RECT 22.130 1.985 22.575 2.790 ;
        RECT 22.865 2.510 23.095 2.555 ;
        RECT 24.105 2.510 24.550 2.790 ;
        RECT 24.950 2.510 25.555 3.075 ;
        RECT 22.865 2.280 24.550 2.510 ;
        RECT 22.865 2.215 23.095 2.280 ;
        RECT 23.600 1.985 23.830 2.050 ;
        RECT 22.130 1.755 23.830 1.985 ;
        RECT 22.130 1.310 22.595 1.755 ;
        RECT 23.600 1.710 23.830 1.755 ;
        RECT 24.105 1.660 24.550 2.280 ;
        RECT 23.105 1.215 23.560 1.480 ;
        RECT 24.060 1.295 24.550 1.660 ;
        RECT 24.920 1.290 25.525 1.855 ;
        RECT 0.000 0.505 0.390 0.940 ;
        RECT 0.610 0.045 1.000 0.425 ;
        RECT 1.435 0.000 1.700 1.215 ;
        RECT 3.110 0.505 3.500 0.940 ;
        RECT 2.240 0.045 2.630 0.425 ;
        RECT 3.720 0.045 4.110 0.425 ;
        RECT 4.545 0.000 4.810 1.215 ;
        RECT 6.220 0.505 6.610 0.940 ;
        RECT 5.350 0.045 5.740 0.425 ;
        RECT 6.830 0.045 7.220 0.425 ;
        RECT 7.655 0.000 7.920 1.215 ;
        RECT 9.330 0.505 9.720 0.940 ;
        RECT 8.460 0.045 8.850 0.425 ;
        RECT 9.940 0.045 10.330 0.425 ;
        RECT 10.765 0.000 11.030 1.215 ;
        RECT 12.440 0.505 12.830 0.940 ;
        RECT 11.570 0.045 11.960 0.425 ;
        RECT 13.050 0.045 13.440 0.425 ;
        RECT 13.875 0.000 14.140 1.215 ;
        RECT 15.550 0.505 15.940 0.940 ;
        RECT 14.680 0.045 15.070 0.425 ;
        RECT 16.160 0.045 16.550 0.425 ;
        RECT 16.985 0.000 17.250 1.215 ;
        RECT 18.660 0.505 19.050 0.940 ;
        RECT 17.790 0.045 18.180 0.425 ;
        RECT 19.270 0.045 19.660 0.425 ;
        RECT 20.095 0.000 20.360 1.215 ;
        RECT 21.770 0.505 22.160 0.940 ;
        RECT 20.900 0.045 21.290 0.425 ;
        RECT 22.380 0.045 22.770 0.425 ;
        RECT 23.205 0.000 23.470 1.215 ;
        RECT 24.010 0.045 24.400 0.425 ;
      LAYER Metal2 ;
        RECT 0.000 42.620 24.880 43.355 ;
        RECT 2.350 41.885 3.110 42.200 ;
        RECT 5.460 41.885 6.220 42.200 ;
        RECT 8.570 41.885 9.330 42.200 ;
        RECT 11.680 41.885 12.440 42.200 ;
        RECT 14.790 41.885 15.550 42.200 ;
        RECT 17.900 41.885 18.660 42.200 ;
        RECT 21.010 41.885 21.770 42.200 ;
        RECT 24.120 41.885 24.880 42.200 ;
        RECT -0.755 41.505 0.140 41.545 ;
        RECT -0.755 40.715 25.625 41.505 ;
        RECT 0.000 40.675 25.625 40.715 ;
        RECT -0.730 39.565 25.570 40.395 ;
        RECT 0.000 38.980 24.880 39.265 ;
        RECT 0.510 38.390 1.010 38.700 ;
        RECT 1.770 38.390 2.670 38.700 ;
        RECT 3.620 38.390 4.120 38.700 ;
        RECT 4.880 38.390 5.780 38.700 ;
        RECT 6.730 38.390 7.230 38.700 ;
        RECT 7.990 38.390 8.890 38.700 ;
        RECT 9.840 38.390 10.340 38.700 ;
        RECT 11.100 38.390 12.000 38.700 ;
        RECT 12.950 38.390 13.450 38.700 ;
        RECT 14.210 38.390 15.110 38.700 ;
        RECT 16.060 38.390 16.560 38.700 ;
        RECT 17.320 38.390 18.220 38.700 ;
        RECT 19.170 38.390 19.670 38.700 ;
        RECT 20.430 38.390 21.330 38.700 ;
        RECT 22.280 38.390 22.780 38.700 ;
        RECT 23.540 38.390 24.440 38.700 ;
        RECT 0.000 37.140 24.880 37.875 ;
        RECT 2.350 36.405 3.110 36.720 ;
        RECT 5.460 36.405 6.220 36.720 ;
        RECT 8.570 36.405 9.330 36.720 ;
        RECT 11.680 36.405 12.440 36.720 ;
        RECT 14.790 36.405 15.550 36.720 ;
        RECT 17.900 36.405 18.660 36.720 ;
        RECT 21.010 36.405 21.770 36.720 ;
        RECT 24.120 36.405 24.880 36.720 ;
        RECT -0.755 36.025 0.140 36.065 ;
        RECT -0.755 35.235 25.625 36.025 ;
        RECT 0.000 35.195 25.625 35.235 ;
        RECT -0.730 34.090 25.570 34.915 ;
        RECT -0.730 34.085 24.880 34.090 ;
        RECT 0.000 33.500 24.880 33.785 ;
        RECT 0.510 32.910 1.010 33.220 ;
        RECT 1.770 32.910 2.670 33.220 ;
        RECT 3.620 32.910 4.120 33.220 ;
        RECT 4.880 32.910 5.780 33.220 ;
        RECT 6.730 32.910 7.230 33.220 ;
        RECT 7.990 32.910 8.890 33.220 ;
        RECT 9.840 32.910 10.340 33.220 ;
        RECT 11.100 32.910 12.000 33.220 ;
        RECT 12.950 32.910 13.450 33.220 ;
        RECT 14.210 32.910 15.110 33.220 ;
        RECT 16.060 32.910 16.560 33.220 ;
        RECT 17.320 32.910 18.220 33.220 ;
        RECT 19.170 32.910 19.670 33.220 ;
        RECT 20.430 32.910 21.330 33.220 ;
        RECT 22.280 32.910 22.780 33.220 ;
        RECT 23.540 32.910 24.440 33.220 ;
        RECT 0.000 31.660 24.880 32.395 ;
        RECT 2.350 30.925 3.110 31.240 ;
        RECT 5.460 30.925 6.220 31.240 ;
        RECT 8.570 30.925 9.330 31.240 ;
        RECT 11.680 30.925 12.440 31.240 ;
        RECT 14.790 30.925 15.550 31.240 ;
        RECT 17.900 30.925 18.660 31.240 ;
        RECT 21.010 30.925 21.770 31.240 ;
        RECT 24.120 30.925 24.880 31.240 ;
        RECT -0.755 30.545 0.140 30.585 ;
        RECT -0.755 29.755 25.625 30.545 ;
        RECT 0.000 29.715 25.625 29.755 ;
        RECT -0.730 28.605 25.570 29.435 ;
        RECT 0.000 28.020 24.880 28.305 ;
        RECT 0.510 27.430 1.010 27.740 ;
        RECT 1.770 27.430 2.670 27.740 ;
        RECT 3.620 27.430 4.120 27.740 ;
        RECT 4.880 27.430 5.780 27.740 ;
        RECT 6.730 27.430 7.230 27.740 ;
        RECT 7.990 27.430 8.890 27.740 ;
        RECT 9.840 27.430 10.340 27.740 ;
        RECT 11.100 27.430 12.000 27.740 ;
        RECT 12.950 27.430 13.450 27.740 ;
        RECT 14.210 27.430 15.110 27.740 ;
        RECT 16.060 27.430 16.560 27.740 ;
        RECT 17.320 27.430 18.220 27.740 ;
        RECT 19.170 27.430 19.670 27.740 ;
        RECT 20.430 27.430 21.330 27.740 ;
        RECT 22.280 27.430 22.780 27.740 ;
        RECT 23.540 27.430 24.440 27.740 ;
        RECT 0.000 26.180 24.880 26.915 ;
        RECT 2.350 25.445 3.110 25.760 ;
        RECT 5.460 25.445 6.220 25.760 ;
        RECT 8.570 25.445 9.330 25.760 ;
        RECT 11.680 25.445 12.440 25.760 ;
        RECT 14.790 25.445 15.550 25.760 ;
        RECT 17.900 25.445 18.660 25.760 ;
        RECT 21.010 25.445 21.770 25.760 ;
        RECT 24.120 25.445 24.880 25.760 ;
        RECT -0.755 25.065 0.140 25.105 ;
        RECT -0.755 24.275 25.625 25.065 ;
        RECT 0.000 24.235 25.625 24.275 ;
        RECT -0.730 23.130 25.570 23.955 ;
        RECT 0.000 23.125 24.880 23.130 ;
        RECT 0.000 22.540 24.880 22.825 ;
        RECT 0.510 21.950 1.010 22.260 ;
        RECT 1.770 21.950 2.670 22.260 ;
        RECT 3.620 21.950 4.120 22.260 ;
        RECT 4.880 21.950 5.780 22.260 ;
        RECT 6.730 21.950 7.230 22.260 ;
        RECT 7.990 21.950 8.890 22.260 ;
        RECT 9.840 21.950 10.340 22.260 ;
        RECT 11.100 21.950 12.000 22.260 ;
        RECT 12.950 21.950 13.450 22.260 ;
        RECT 14.210 21.950 15.110 22.260 ;
        RECT 16.060 21.950 16.560 22.260 ;
        RECT 17.320 21.950 18.220 22.260 ;
        RECT 19.170 21.950 19.670 22.260 ;
        RECT 20.430 21.950 21.330 22.260 ;
        RECT 22.280 21.950 22.780 22.260 ;
        RECT 23.540 21.950 24.440 22.260 ;
        RECT 0.000 20.700 24.880 21.435 ;
        RECT 2.350 19.965 3.110 20.280 ;
        RECT 5.460 19.965 6.220 20.280 ;
        RECT 8.570 19.965 9.330 20.280 ;
        RECT 11.680 19.965 12.440 20.280 ;
        RECT 14.790 19.965 15.550 20.280 ;
        RECT 17.900 19.965 18.660 20.280 ;
        RECT 21.010 19.965 21.770 20.280 ;
        RECT 24.120 19.965 24.880 20.280 ;
        RECT -0.755 19.585 0.140 19.625 ;
        RECT -0.755 18.795 25.625 19.585 ;
        RECT 0.000 18.755 25.625 18.795 ;
        RECT -0.730 17.650 25.570 18.475 ;
        RECT -0.730 17.645 24.880 17.650 ;
        RECT 0.000 17.060 24.880 17.345 ;
        RECT 0.510 16.470 1.010 16.780 ;
        RECT 1.770 16.470 2.670 16.780 ;
        RECT 3.620 16.470 4.120 16.780 ;
        RECT 4.880 16.470 5.780 16.780 ;
        RECT 6.730 16.470 7.230 16.780 ;
        RECT 7.990 16.470 8.890 16.780 ;
        RECT 9.840 16.470 10.340 16.780 ;
        RECT 11.100 16.470 12.000 16.780 ;
        RECT 12.950 16.470 13.450 16.780 ;
        RECT 14.210 16.470 15.110 16.780 ;
        RECT 16.060 16.470 16.560 16.780 ;
        RECT 17.320 16.470 18.220 16.780 ;
        RECT 19.170 16.470 19.670 16.780 ;
        RECT 20.430 16.470 21.330 16.780 ;
        RECT 22.280 16.470 22.780 16.780 ;
        RECT 23.540 16.470 24.440 16.780 ;
        RECT 0.000 15.220 24.880 15.955 ;
        RECT 2.350 14.485 3.110 14.800 ;
        RECT 5.460 14.485 6.220 14.800 ;
        RECT 8.570 14.485 9.330 14.800 ;
        RECT 11.680 14.485 12.440 14.800 ;
        RECT 14.790 14.485 15.550 14.800 ;
        RECT 17.900 14.485 18.660 14.800 ;
        RECT 21.010 14.485 21.770 14.800 ;
        RECT 24.120 14.485 24.880 14.800 ;
        RECT -0.755 14.105 0.140 14.150 ;
        RECT -0.755 13.320 25.625 14.105 ;
        RECT 0.000 13.275 25.625 13.320 ;
        RECT -0.730 12.175 25.570 12.995 ;
        RECT -0.730 12.170 24.880 12.175 ;
        RECT 0.000 12.165 24.880 12.170 ;
        RECT 0.000 11.580 24.880 11.865 ;
        RECT 0.510 10.990 1.010 11.300 ;
        RECT 1.770 10.990 2.670 11.300 ;
        RECT 3.620 10.990 4.120 11.300 ;
        RECT 4.880 10.990 5.780 11.300 ;
        RECT 6.730 10.990 7.230 11.300 ;
        RECT 7.990 10.990 8.890 11.300 ;
        RECT 9.840 10.990 10.340 11.300 ;
        RECT 11.100 10.990 12.000 11.300 ;
        RECT 12.950 10.990 13.450 11.300 ;
        RECT 14.210 10.990 15.110 11.300 ;
        RECT 16.060 10.990 16.560 11.300 ;
        RECT 17.320 10.990 18.220 11.300 ;
        RECT 19.170 10.990 19.670 11.300 ;
        RECT 20.430 10.990 21.330 11.300 ;
        RECT 22.280 10.990 22.780 11.300 ;
        RECT 23.540 10.990 24.440 11.300 ;
        RECT 0.000 9.740 24.880 10.475 ;
        RECT 2.350 9.005 3.110 9.320 ;
        RECT 5.460 9.005 6.220 9.320 ;
        RECT 8.570 9.005 9.330 9.320 ;
        RECT 11.680 9.005 12.440 9.320 ;
        RECT 14.790 9.005 15.550 9.320 ;
        RECT 17.900 9.005 18.660 9.320 ;
        RECT 21.010 9.005 21.770 9.320 ;
        RECT 24.120 9.005 24.880 9.320 ;
        RECT -0.755 8.625 0.140 8.665 ;
        RECT -0.755 7.835 25.625 8.625 ;
        RECT 0.000 7.795 25.625 7.835 ;
        RECT -0.730 6.735 25.570 7.515 ;
        RECT 0.000 6.690 25.570 6.735 ;
        RECT 0.000 6.685 24.880 6.690 ;
        RECT 0.000 6.100 24.880 6.385 ;
        RECT 0.510 5.510 1.010 5.820 ;
        RECT 1.770 5.510 2.670 5.820 ;
        RECT 3.620 5.510 4.120 5.820 ;
        RECT 4.880 5.510 5.780 5.820 ;
        RECT 6.730 5.510 7.230 5.820 ;
        RECT 7.990 5.510 8.890 5.820 ;
        RECT 9.840 5.510 10.340 5.820 ;
        RECT 11.100 5.510 12.000 5.820 ;
        RECT 12.950 5.510 13.450 5.820 ;
        RECT 14.210 5.510 15.110 5.820 ;
        RECT 16.060 5.510 16.560 5.820 ;
        RECT 17.320 5.510 18.220 5.820 ;
        RECT 19.170 5.510 19.670 5.820 ;
        RECT 20.430 5.510 21.330 5.820 ;
        RECT 22.280 5.510 22.780 5.820 ;
        RECT 23.540 5.510 24.440 5.820 ;
        RECT 0.000 4.260 24.880 4.995 ;
        RECT 2.350 3.525 3.110 3.840 ;
        RECT 5.460 3.525 6.220 3.840 ;
        RECT 8.570 3.525 9.330 3.840 ;
        RECT 11.680 3.525 12.440 3.840 ;
        RECT 14.790 3.525 15.550 3.840 ;
        RECT 17.900 3.525 18.660 3.840 ;
        RECT 21.010 3.525 21.770 3.840 ;
        RECT 24.120 3.525 24.880 3.840 ;
        RECT -0.755 3.145 0.140 3.185 ;
        RECT -0.755 2.355 25.625 3.145 ;
        RECT 0.000 2.315 25.625 2.355 ;
        RECT -0.730 1.210 25.570 2.035 ;
        RECT -0.730 1.205 24.880 1.210 ;
        RECT 0.000 0.620 24.880 0.905 ;
        RECT 0.510 0.030 1.010 0.340 ;
        RECT 1.770 0.030 2.670 0.340 ;
        RECT 3.620 0.030 4.120 0.340 ;
        RECT 4.880 0.030 5.780 0.340 ;
        RECT 6.730 0.030 7.230 0.340 ;
        RECT 7.990 0.030 8.890 0.340 ;
        RECT 9.840 0.030 10.340 0.340 ;
        RECT 11.100 0.030 12.000 0.340 ;
        RECT 12.950 0.030 13.450 0.340 ;
        RECT 14.210 0.030 15.110 0.340 ;
        RECT 16.060 0.030 16.560 0.340 ;
        RECT 17.320 0.030 18.220 0.340 ;
        RECT 19.170 0.030 19.670 0.340 ;
        RECT 20.430 0.030 21.330 0.340 ;
        RECT 22.280 0.030 22.780 0.340 ;
        RECT 23.540 0.030 24.440 0.340 ;
      LAYER Metal3 ;
        RECT 0.520 0.000 1.010 43.840 ;
        RECT 1.765 39.545 2.255 43.840 ;
        RECT 2.640 41.805 3.085 42.320 ;
        RECT 1.770 38.360 2.255 39.545 ;
        RECT 1.765 34.065 2.255 38.360 ;
        RECT 2.640 36.325 3.085 36.840 ;
        RECT 1.770 32.880 2.255 34.065 ;
        RECT 1.765 28.585 2.255 32.880 ;
        RECT 2.640 30.845 3.085 31.360 ;
        RECT 1.770 27.400 2.255 28.585 ;
        RECT 1.765 23.105 2.255 27.400 ;
        RECT 2.640 25.365 3.085 25.880 ;
        RECT 1.770 21.920 2.255 23.105 ;
        RECT 1.765 17.625 2.255 21.920 ;
        RECT 2.640 19.885 3.085 20.400 ;
        RECT 1.770 16.440 2.255 17.625 ;
        RECT 1.765 12.145 2.255 16.440 ;
        RECT 2.640 14.405 3.085 14.920 ;
        RECT 1.770 10.960 2.255 12.145 ;
        RECT 1.765 6.665 2.255 10.960 ;
        RECT 2.640 8.925 3.085 9.440 ;
        RECT 1.770 5.480 2.255 6.665 ;
        RECT 1.765 1.185 2.255 5.480 ;
        RECT 2.640 3.445 3.085 3.960 ;
        RECT 1.770 0.000 2.255 1.185 ;
        RECT 3.630 0.000 4.120 43.840 ;
        RECT 4.875 39.545 5.365 43.840 ;
        RECT 5.750 41.805 6.195 42.320 ;
        RECT 4.880 38.360 5.365 39.545 ;
        RECT 4.875 34.065 5.365 38.360 ;
        RECT 5.750 36.325 6.195 36.840 ;
        RECT 4.880 32.880 5.365 34.065 ;
        RECT 4.875 28.585 5.365 32.880 ;
        RECT 5.750 30.845 6.195 31.360 ;
        RECT 4.880 27.400 5.365 28.585 ;
        RECT 4.875 23.105 5.365 27.400 ;
        RECT 5.750 25.365 6.195 25.880 ;
        RECT 4.880 21.920 5.365 23.105 ;
        RECT 4.875 17.625 5.365 21.920 ;
        RECT 5.750 19.885 6.195 20.400 ;
        RECT 4.880 16.440 5.365 17.625 ;
        RECT 4.875 12.145 5.365 16.440 ;
        RECT 5.750 14.405 6.195 14.920 ;
        RECT 4.880 10.960 5.365 12.145 ;
        RECT 4.875 6.665 5.365 10.960 ;
        RECT 5.750 8.925 6.195 9.440 ;
        RECT 4.880 5.480 5.365 6.665 ;
        RECT 4.875 1.185 5.365 5.480 ;
        RECT 5.750 3.445 6.195 3.960 ;
        RECT 4.880 0.000 5.365 1.185 ;
        RECT 6.740 0.000 7.230 43.840 ;
        RECT 7.985 39.545 8.475 43.840 ;
        RECT 8.860 41.805 9.305 42.320 ;
        RECT 7.990 38.360 8.475 39.545 ;
        RECT 7.985 34.065 8.475 38.360 ;
        RECT 8.860 36.325 9.305 36.840 ;
        RECT 7.990 32.880 8.475 34.065 ;
        RECT 7.985 28.585 8.475 32.880 ;
        RECT 8.860 30.845 9.305 31.360 ;
        RECT 7.990 27.400 8.475 28.585 ;
        RECT 7.985 23.105 8.475 27.400 ;
        RECT 8.860 25.365 9.305 25.880 ;
        RECT 7.990 21.920 8.475 23.105 ;
        RECT 7.985 17.625 8.475 21.920 ;
        RECT 8.860 19.885 9.305 20.400 ;
        RECT 7.990 16.440 8.475 17.625 ;
        RECT 7.985 12.145 8.475 16.440 ;
        RECT 8.860 14.405 9.305 14.920 ;
        RECT 7.990 10.960 8.475 12.145 ;
        RECT 7.985 6.665 8.475 10.960 ;
        RECT 8.860 8.925 9.305 9.440 ;
        RECT 7.990 5.480 8.475 6.665 ;
        RECT 7.985 1.185 8.475 5.480 ;
        RECT 8.860 3.445 9.305 3.960 ;
        RECT 7.990 0.000 8.475 1.185 ;
        RECT 9.850 0.000 10.340 43.840 ;
        RECT 11.095 39.545 11.585 43.840 ;
        RECT 11.970 41.805 12.415 42.320 ;
        RECT 11.100 38.360 11.585 39.545 ;
        RECT 11.095 34.065 11.585 38.360 ;
        RECT 11.970 36.325 12.415 36.840 ;
        RECT 11.100 32.880 11.585 34.065 ;
        RECT 11.095 28.585 11.585 32.880 ;
        RECT 11.970 30.845 12.415 31.360 ;
        RECT 11.100 27.400 11.585 28.585 ;
        RECT 11.095 23.105 11.585 27.400 ;
        RECT 11.970 25.365 12.415 25.880 ;
        RECT 11.100 21.920 11.585 23.105 ;
        RECT 11.095 17.625 11.585 21.920 ;
        RECT 11.970 19.885 12.415 20.400 ;
        RECT 11.100 16.440 11.585 17.625 ;
        RECT 11.095 12.145 11.585 16.440 ;
        RECT 11.970 14.405 12.415 14.920 ;
        RECT 11.100 10.960 11.585 12.145 ;
        RECT 11.095 6.665 11.585 10.960 ;
        RECT 11.970 8.925 12.415 9.440 ;
        RECT 11.100 5.480 11.585 6.665 ;
        RECT 11.095 1.185 11.585 5.480 ;
        RECT 11.970 3.445 12.415 3.960 ;
        RECT 11.100 0.000 11.585 1.185 ;
        RECT 12.960 0.000 13.450 43.840 ;
        RECT 14.205 39.545 14.695 43.840 ;
        RECT 15.080 41.805 15.525 42.320 ;
        RECT 14.210 38.360 14.695 39.545 ;
        RECT 14.205 34.065 14.695 38.360 ;
        RECT 15.080 36.325 15.525 36.840 ;
        RECT 14.210 32.880 14.695 34.065 ;
        RECT 14.205 28.585 14.695 32.880 ;
        RECT 15.080 30.845 15.525 31.360 ;
        RECT 14.210 27.400 14.695 28.585 ;
        RECT 14.205 23.105 14.695 27.400 ;
        RECT 15.080 25.365 15.525 25.880 ;
        RECT 14.210 21.920 14.695 23.105 ;
        RECT 14.205 17.625 14.695 21.920 ;
        RECT 15.080 19.885 15.525 20.400 ;
        RECT 14.210 16.440 14.695 17.625 ;
        RECT 14.205 12.145 14.695 16.440 ;
        RECT 15.080 14.405 15.525 14.920 ;
        RECT 14.210 10.960 14.695 12.145 ;
        RECT 14.205 6.665 14.695 10.960 ;
        RECT 15.080 8.925 15.525 9.440 ;
        RECT 14.210 5.480 14.695 6.665 ;
        RECT 14.205 1.185 14.695 5.480 ;
        RECT 15.080 3.445 15.525 3.960 ;
        RECT 14.210 0.000 14.695 1.185 ;
        RECT 16.070 0.000 16.560 43.840 ;
        RECT 17.315 39.545 17.805 43.840 ;
        RECT 18.190 41.805 18.635 42.320 ;
        RECT 17.320 38.360 17.805 39.545 ;
        RECT 17.315 34.065 17.805 38.360 ;
        RECT 18.190 36.325 18.635 36.840 ;
        RECT 17.320 32.880 17.805 34.065 ;
        RECT 17.315 28.585 17.805 32.880 ;
        RECT 18.190 30.845 18.635 31.360 ;
        RECT 17.320 27.400 17.805 28.585 ;
        RECT 17.315 23.105 17.805 27.400 ;
        RECT 18.190 25.365 18.635 25.880 ;
        RECT 17.320 21.920 17.805 23.105 ;
        RECT 17.315 17.625 17.805 21.920 ;
        RECT 18.190 19.885 18.635 20.400 ;
        RECT 17.320 16.440 17.805 17.625 ;
        RECT 17.315 12.145 17.805 16.440 ;
        RECT 18.190 14.405 18.635 14.920 ;
        RECT 17.320 10.960 17.805 12.145 ;
        RECT 17.315 6.665 17.805 10.960 ;
        RECT 18.190 8.925 18.635 9.440 ;
        RECT 17.320 5.480 17.805 6.665 ;
        RECT 17.315 1.185 17.805 5.480 ;
        RECT 18.190 3.445 18.635 3.960 ;
        RECT 17.320 0.000 17.805 1.185 ;
        RECT 19.180 0.000 19.670 43.840 ;
        RECT 20.425 39.545 20.915 43.840 ;
        RECT 21.300 41.805 21.745 42.320 ;
        RECT 20.430 38.360 20.915 39.545 ;
        RECT 20.425 34.065 20.915 38.360 ;
        RECT 21.300 36.325 21.745 36.840 ;
        RECT 20.430 32.880 20.915 34.065 ;
        RECT 20.425 28.585 20.915 32.880 ;
        RECT 21.300 30.845 21.745 31.360 ;
        RECT 20.430 27.400 20.915 28.585 ;
        RECT 20.425 23.105 20.915 27.400 ;
        RECT 21.300 25.365 21.745 25.880 ;
        RECT 20.430 21.920 20.915 23.105 ;
        RECT 20.425 17.625 20.915 21.920 ;
        RECT 21.300 19.885 21.745 20.400 ;
        RECT 20.430 16.440 20.915 17.625 ;
        RECT 20.425 12.145 20.915 16.440 ;
        RECT 21.300 14.405 21.745 14.920 ;
        RECT 20.430 10.960 20.915 12.145 ;
        RECT 20.425 6.665 20.915 10.960 ;
        RECT 21.300 8.925 21.745 9.440 ;
        RECT 20.430 5.480 20.915 6.665 ;
        RECT 20.425 1.185 20.915 5.480 ;
        RECT 21.300 3.445 21.745 3.960 ;
        RECT 20.430 0.000 20.915 1.185 ;
        RECT 22.290 0.000 22.780 43.840 ;
        RECT 23.535 39.545 24.025 43.840 ;
        RECT 24.410 41.805 24.855 42.320 ;
        RECT 23.540 38.360 24.025 39.545 ;
        RECT 23.535 34.065 24.025 38.360 ;
        RECT 24.410 36.325 24.855 36.840 ;
        RECT 23.540 32.880 24.025 34.065 ;
        RECT 23.535 28.585 24.025 32.880 ;
        RECT 24.410 30.845 24.855 31.360 ;
        RECT 23.540 27.400 24.025 28.585 ;
        RECT 23.535 23.105 24.025 27.400 ;
        RECT 24.410 25.365 24.855 25.880 ;
        RECT 23.540 21.920 24.025 23.105 ;
        RECT 23.535 17.625 24.025 21.920 ;
        RECT 24.410 19.885 24.855 20.400 ;
        RECT 23.540 16.440 24.025 17.625 ;
        RECT 23.535 12.145 24.025 16.440 ;
        RECT 24.410 14.405 24.855 14.920 ;
        RECT 23.540 10.960 24.025 12.145 ;
        RECT 23.535 6.665 24.025 10.960 ;
        RECT 24.410 8.925 24.855 9.440 ;
        RECT 23.540 5.480 24.025 6.665 ;
        RECT 23.535 1.185 24.025 5.480 ;
        RECT 24.410 3.445 24.855 3.960 ;
        RECT 23.540 0.000 24.025 1.185 ;
      LAYER Metal4 ;
        RECT 0.605 40.295 0.885 44.340 ;
        RECT 1.310 40.880 1.590 44.340 ;
        RECT 2.015 41.485 2.295 44.340 ;
        RECT 2.720 41.820 3.000 44.340 ;
        RECT 2.015 41.205 3.000 41.485 ;
        RECT 1.310 40.600 2.295 40.880 ;
        RECT 0.605 40.015 1.695 40.295 ;
        RECT 1.415 35.375 1.695 40.015 ;
        RECT 2.015 36.005 2.295 40.600 ;
        RECT 2.720 36.340 3.000 41.205 ;
        RECT 3.715 40.295 3.995 44.340 ;
        RECT 4.420 40.880 4.700 44.340 ;
        RECT 5.125 41.485 5.405 44.340 ;
        RECT 5.830 41.820 6.110 44.340 ;
        RECT 5.125 41.205 6.110 41.485 ;
        RECT 4.420 40.600 5.405 40.880 ;
        RECT 3.715 40.015 4.805 40.295 ;
        RECT 2.015 35.725 3.000 36.005 ;
        RECT 1.415 35.095 2.395 35.375 ;
        RECT 2.115 30.535 2.395 35.095 ;
        RECT 2.720 30.860 3.000 35.725 ;
        RECT 4.525 35.375 4.805 40.015 ;
        RECT 5.125 36.005 5.405 40.600 ;
        RECT 5.830 36.340 6.110 41.205 ;
        RECT 6.825 40.295 7.105 44.340 ;
        RECT 7.530 40.880 7.810 44.340 ;
        RECT 8.235 41.485 8.515 44.340 ;
        RECT 8.940 41.820 9.220 44.340 ;
        RECT 8.235 41.205 9.220 41.485 ;
        RECT 7.530 40.600 8.515 40.880 ;
        RECT 6.825 40.015 7.915 40.295 ;
        RECT 5.125 35.725 6.110 36.005 ;
        RECT 4.525 35.095 5.505 35.375 ;
        RECT 5.225 30.535 5.505 35.095 ;
        RECT 5.830 30.860 6.110 35.725 ;
        RECT 7.635 35.375 7.915 40.015 ;
        RECT 8.235 36.005 8.515 40.600 ;
        RECT 8.940 36.340 9.220 41.205 ;
        RECT 9.935 40.295 10.215 44.340 ;
        RECT 10.640 40.880 10.920 44.340 ;
        RECT 11.345 41.485 11.625 44.340 ;
        RECT 12.050 41.820 12.330 44.340 ;
        RECT 11.345 41.205 12.330 41.485 ;
        RECT 10.640 40.600 11.625 40.880 ;
        RECT 9.935 40.015 11.025 40.295 ;
        RECT 8.235 35.725 9.220 36.005 ;
        RECT 7.635 35.095 8.615 35.375 ;
        RECT 8.335 30.535 8.615 35.095 ;
        RECT 8.940 30.860 9.220 35.725 ;
        RECT 10.745 35.375 11.025 40.015 ;
        RECT 11.345 36.005 11.625 40.600 ;
        RECT 12.050 36.340 12.330 41.205 ;
        RECT 13.045 40.295 13.325 44.340 ;
        RECT 13.750 40.880 14.030 44.340 ;
        RECT 14.455 41.485 14.735 44.340 ;
        RECT 15.160 41.820 15.440 44.340 ;
        RECT 14.455 41.205 15.440 41.485 ;
        RECT 13.750 40.600 14.735 40.880 ;
        RECT 13.045 40.015 14.135 40.295 ;
        RECT 11.345 35.725 12.330 36.005 ;
        RECT 10.745 35.095 11.725 35.375 ;
        RECT 11.445 30.535 11.725 35.095 ;
        RECT 12.050 30.860 12.330 35.725 ;
        RECT 13.855 35.375 14.135 40.015 ;
        RECT 14.455 36.005 14.735 40.600 ;
        RECT 15.160 36.340 15.440 41.205 ;
        RECT 16.155 40.295 16.435 44.340 ;
        RECT 16.860 40.880 17.140 44.340 ;
        RECT 17.565 41.485 17.845 44.340 ;
        RECT 18.270 41.820 18.550 44.340 ;
        RECT 17.565 41.205 18.550 41.485 ;
        RECT 16.860 40.600 17.845 40.880 ;
        RECT 16.155 40.015 17.245 40.295 ;
        RECT 14.455 35.725 15.440 36.005 ;
        RECT 13.855 35.095 14.835 35.375 ;
        RECT 14.555 30.535 14.835 35.095 ;
        RECT 15.160 30.860 15.440 35.725 ;
        RECT 16.965 35.375 17.245 40.015 ;
        RECT 17.565 36.005 17.845 40.600 ;
        RECT 18.270 36.340 18.550 41.205 ;
        RECT 19.265 40.295 19.545 44.340 ;
        RECT 19.970 40.880 20.250 44.340 ;
        RECT 20.675 41.485 20.955 44.340 ;
        RECT 21.380 41.820 21.660 44.340 ;
        RECT 20.675 41.205 21.660 41.485 ;
        RECT 19.970 40.600 20.955 40.880 ;
        RECT 19.265 40.015 20.355 40.295 ;
        RECT 17.565 35.725 18.550 36.005 ;
        RECT 16.965 35.095 17.945 35.375 ;
        RECT 17.665 30.535 17.945 35.095 ;
        RECT 18.270 30.860 18.550 35.725 ;
        RECT 20.075 35.375 20.355 40.015 ;
        RECT 20.675 36.005 20.955 40.600 ;
        RECT 21.380 36.340 21.660 41.205 ;
        RECT 22.375 40.295 22.655 44.340 ;
        RECT 23.080 40.880 23.360 44.340 ;
        RECT 23.785 41.485 24.065 44.340 ;
        RECT 24.490 41.820 24.770 44.340 ;
        RECT 23.785 41.205 24.770 41.485 ;
        RECT 23.080 40.600 24.065 40.880 ;
        RECT 22.375 40.015 23.465 40.295 ;
        RECT 20.675 35.725 21.660 36.005 ;
        RECT 20.075 35.095 21.055 35.375 ;
        RECT 20.775 30.535 21.055 35.095 ;
        RECT 21.380 30.860 21.660 35.725 ;
        RECT 23.185 35.375 23.465 40.015 ;
        RECT 23.785 36.005 24.065 40.600 ;
        RECT 24.490 36.340 24.770 41.205 ;
        RECT 23.785 35.725 24.770 36.005 ;
        RECT 23.185 35.095 24.165 35.375 ;
        RECT 23.885 30.535 24.165 35.095 ;
        RECT 24.490 30.860 24.770 35.725 ;
        RECT 2.115 30.255 3.000 30.535 ;
        RECT 5.225 30.255 6.110 30.535 ;
        RECT 8.335 30.255 9.220 30.535 ;
        RECT 11.445 30.255 12.330 30.535 ;
        RECT 14.555 30.255 15.440 30.535 ;
        RECT 17.665 30.255 18.550 30.535 ;
        RECT 20.775 30.255 21.660 30.535 ;
        RECT 23.885 30.255 24.770 30.535 ;
        RECT 2.720 25.380 3.000 30.255 ;
        RECT 5.830 25.380 6.110 30.255 ;
        RECT 8.940 25.380 9.220 30.255 ;
        RECT 12.050 25.380 12.330 30.255 ;
        RECT 15.160 25.380 15.440 30.255 ;
        RECT 18.270 25.380 18.550 30.255 ;
        RECT 21.380 25.380 21.660 30.255 ;
        RECT 24.490 25.380 24.770 30.255 ;
        RECT 2.720 15.515 3.000 20.425 ;
        RECT 5.830 15.520 6.110 20.425 ;
        RECT 8.940 15.520 9.220 20.425 ;
        RECT 12.050 15.520 12.330 20.425 ;
        RECT 15.160 15.520 15.440 20.425 ;
        RECT 18.270 15.520 18.550 20.425 ;
        RECT 21.380 15.520 21.660 20.425 ;
        RECT 24.490 15.520 24.770 20.425 ;
        RECT 2.020 15.235 3.000 15.515 ;
        RECT 5.130 15.240 6.110 15.520 ;
        RECT 8.240 15.240 9.220 15.520 ;
        RECT 11.350 15.240 12.330 15.520 ;
        RECT 14.460 15.240 15.440 15.520 ;
        RECT 17.570 15.240 18.550 15.520 ;
        RECT 20.680 15.240 21.660 15.520 ;
        RECT 23.790 15.240 24.770 15.520 ;
        RECT 2.020 10.610 2.300 15.235 ;
        RECT 1.370 10.330 2.300 10.610 ;
        RECT 1.370 5.940 1.650 10.330 ;
        RECT 2.720 10.035 3.000 14.945 ;
        RECT 5.130 10.615 5.410 15.240 ;
        RECT 0.620 5.660 1.650 5.940 ;
        RECT 2.020 9.755 3.000 10.035 ;
        RECT 4.480 10.335 5.410 10.615 ;
        RECT 0.620 -0.540 0.900 5.660 ;
        RECT 2.020 5.210 2.300 9.755 ;
        RECT 1.320 4.930 2.300 5.210 ;
        RECT 1.320 -0.540 1.600 4.930 ;
        RECT 2.720 4.555 3.000 9.465 ;
        RECT 4.480 5.945 4.760 10.335 ;
        RECT 5.830 10.040 6.110 14.945 ;
        RECT 8.240 10.615 8.520 15.240 ;
        RECT 2.020 4.275 3.000 4.555 ;
        RECT 3.730 5.665 4.760 5.945 ;
        RECT 5.130 9.760 6.110 10.040 ;
        RECT 7.590 10.335 8.520 10.615 ;
        RECT 2.020 -0.540 2.300 4.275 ;
        RECT 2.720 -0.540 3.000 3.985 ;
        RECT 3.730 -0.540 4.010 5.665 ;
        RECT 5.130 5.215 5.410 9.760 ;
        RECT 4.430 4.935 5.410 5.215 ;
        RECT 4.430 -0.540 4.710 4.935 ;
        RECT 5.830 4.560 6.110 9.465 ;
        RECT 7.590 5.945 7.870 10.335 ;
        RECT 8.940 10.040 9.220 14.945 ;
        RECT 11.350 10.615 11.630 15.240 ;
        RECT 5.130 4.280 6.110 4.560 ;
        RECT 6.840 5.665 7.870 5.945 ;
        RECT 8.240 9.760 9.220 10.040 ;
        RECT 10.700 10.335 11.630 10.615 ;
        RECT 5.130 -0.540 5.410 4.280 ;
        RECT 5.830 -0.540 6.110 3.985 ;
        RECT 6.840 -0.540 7.120 5.665 ;
        RECT 8.240 5.215 8.520 9.760 ;
        RECT 7.540 4.935 8.520 5.215 ;
        RECT 7.540 -0.540 7.820 4.935 ;
        RECT 8.940 4.560 9.220 9.465 ;
        RECT 10.700 5.945 10.980 10.335 ;
        RECT 12.050 10.040 12.330 14.945 ;
        RECT 14.460 10.615 14.740 15.240 ;
        RECT 8.240 4.280 9.220 4.560 ;
        RECT 9.950 5.665 10.980 5.945 ;
        RECT 11.350 9.760 12.330 10.040 ;
        RECT 13.810 10.335 14.740 10.615 ;
        RECT 8.240 -0.540 8.520 4.280 ;
        RECT 8.940 -0.540 9.220 3.985 ;
        RECT 9.950 -0.540 10.230 5.665 ;
        RECT 11.350 5.215 11.630 9.760 ;
        RECT 10.650 4.935 11.630 5.215 ;
        RECT 10.650 -0.540 10.930 4.935 ;
        RECT 12.050 4.560 12.330 9.465 ;
        RECT 13.810 5.945 14.090 10.335 ;
        RECT 15.160 10.040 15.440 14.945 ;
        RECT 17.570 10.615 17.850 15.240 ;
        RECT 11.350 4.280 12.330 4.560 ;
        RECT 13.060 5.665 14.090 5.945 ;
        RECT 14.460 9.760 15.440 10.040 ;
        RECT 16.920 10.335 17.850 10.615 ;
        RECT 11.350 -0.540 11.630 4.280 ;
        RECT 12.050 -0.540 12.330 3.985 ;
        RECT 13.060 -0.540 13.340 5.665 ;
        RECT 14.460 5.215 14.740 9.760 ;
        RECT 13.760 4.935 14.740 5.215 ;
        RECT 13.760 -0.490 14.040 4.935 ;
        RECT 15.160 4.560 15.440 9.465 ;
        RECT 16.920 5.945 17.200 10.335 ;
        RECT 18.270 10.040 18.550 14.945 ;
        RECT 20.680 10.615 20.960 15.240 ;
        RECT 14.460 4.280 15.440 4.560 ;
        RECT 16.170 5.665 17.200 5.945 ;
        RECT 17.570 9.760 18.550 10.040 ;
        RECT 20.030 10.335 20.960 10.615 ;
        RECT 14.460 -0.490 14.740 4.280 ;
        RECT 15.160 -0.490 15.440 3.985 ;
        RECT 16.170 -0.490 16.450 5.665 ;
        RECT 17.570 5.215 17.850 9.760 ;
        RECT 16.870 4.935 17.850 5.215 ;
        RECT 16.870 -0.490 17.150 4.935 ;
        RECT 18.270 4.560 18.550 9.465 ;
        RECT 20.030 5.945 20.310 10.335 ;
        RECT 21.380 10.040 21.660 14.945 ;
        RECT 23.790 10.615 24.070 15.240 ;
        RECT 17.570 4.280 18.550 4.560 ;
        RECT 19.280 5.665 20.310 5.945 ;
        RECT 20.680 9.760 21.660 10.040 ;
        RECT 23.140 10.335 24.070 10.615 ;
        RECT 17.570 -0.490 17.850 4.280 ;
        RECT 18.270 -0.490 18.550 3.985 ;
        RECT 19.280 -0.490 19.560 5.665 ;
        RECT 20.680 5.215 20.960 9.760 ;
        RECT 19.980 4.935 20.960 5.215 ;
        RECT 19.980 -0.490 20.260 4.935 ;
        RECT 21.380 4.560 21.660 9.465 ;
        RECT 23.140 5.945 23.420 10.335 ;
        RECT 24.490 10.040 24.770 14.945 ;
        RECT 20.680 4.280 21.660 4.560 ;
        RECT 22.390 5.665 23.420 5.945 ;
        RECT 23.790 9.760 24.770 10.040 ;
        RECT 20.680 -0.490 20.960 4.280 ;
        RECT 21.380 -0.490 21.660 3.985 ;
        RECT 22.390 -0.490 22.670 5.665 ;
        RECT 23.790 5.215 24.070 9.760 ;
        RECT 23.090 4.935 24.070 5.215 ;
        RECT 23.090 -0.490 23.370 4.935 ;
        RECT 24.490 4.560 24.770 9.465 ;
        RECT 23.790 4.280 24.770 4.560 ;
        RECT 23.790 -0.490 24.070 4.280 ;
        RECT 24.490 -0.490 24.770 3.985 ;
  END
END sram_8x8_9T
END LIBRARY

