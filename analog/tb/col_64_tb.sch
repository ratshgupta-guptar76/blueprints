v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 1 830 -350 {}
C {analog/designs/col_64.sym} 640 -310 0 0 {name=x1}
C {ipin.sym} 490 -360 0 0 {name=p1 lab=vdd}
C {ipin.sym} 490 -340 0 0 {name=p2 lab=vss}
C {ipin.sym} 490 -320 0 0 {name=p3 lab=wbl
}
C {ipin.sym} 490 -300 0 0 {name=p4 lab=wl[63:0]}
C {ipin.sym} 490 -280 0 0 {name=p5 lab=wblb}
C {ipin.sym} 490 -260 0 0 {name=p6 lab=a[63:0]}
C {opin.sym} 790 -360 0 0 {name=p7 lab=rbl}
C {title.sym} 170 -40 0 0 {name=l1 author="Ratish V. Gupta"}
